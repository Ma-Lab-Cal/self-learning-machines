.title linear
R0 0 1 1.8685336250822586
R1 0 2 1.190006702726595
R2 0 3 0.7860119527545264
R3 0 4 0.3897740125527219
R4 1 3 1.7787629085466432
R5 2 3 1.510789968892222
R6 2 4 1.8292464283327883
R7 3 4 1.2920923930569492
V2 2 0 0.9717207560704448
V3 3 0 0.7350337526081114
.op
