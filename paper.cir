.title paper
R1 1 2 1
R2 1 3 1
R3 1 4 1
R4 1 5 1
R5 1 6 1
R6 3 4 1
R7 3 5 1
R8 4 5 1
R9 5 6 1
R10 2 6 1
R16 2 6 1
R11 9 6 1
R12 9 7 1
R13 9 8 1
R14 7 8 1
R15 6 7 1
V1 1 0 0.8314790306013978
V7 7 0 0.5057851657032325
.op
