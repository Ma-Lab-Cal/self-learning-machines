.title fully connected
R0 0 1 1.3240412123936987
R1 0 2 0.8552405791668264
R2 0 3 1.0812216086980637
R3 0 4 1.2287689258774568
R4 1 2 1.082768355290859
R5 1 3 1.1269378839915936
R6 1 4 1.1248409682157035
R7 2 3 1.054959472604847
R8 2 4 1.4520480350390021
R9 3 4 0.8339599014771899
V1 1 0 0.5219806824367224
V3 3 0 0.8020543346692914
.op
