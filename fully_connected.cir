.title fully_connected
R0 0 1 0.6854247876722153
R1 0 2 1.000000000416794e-09
R2 0 3 1.0000000030776074e-09
R3 0 4 1.3433092388725736
R4 1 2 0.09352565507560903
R5 1 3 0.03035038582163145
R6 1 4 2.3507417092121585
R7 2 3 1.000000000416794e-09
R8 2 4 0.05269228301681268
R9 3 4 0.01577187922839325
V1 1 0 0.5928766406569381
V4 4 0 1.0
.op
