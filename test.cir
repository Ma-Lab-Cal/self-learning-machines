*

R100 1 0 1.576229998387043
R200 2 0 0.9220580399711865
R201 2 1 1.377229868721624
R300 3 0 1.0034969268985465
R301 3 1 0.657104426114816
R302 3 2 0.8988233658509736
R400 4 0 1.4319027062627288
R401 4 1 0.265504665276338
R402 4 2 0.17506798017723202
R403 4 3 0.5734297177769928
R500 5 0 0.9969043431668035
R501 5 1 0.4563495985309287
R502 5 2 0.9545882378919436
R503 5 3 0.6230990276570733
R504 5 4 0.7123560687535894
R600 6 0 0.9497808574303438
R601 6 1 0.2878902818876523
R602 6 2 0.9208772557392355
R603 6 3 1.147907860961206
R604 6 4 1.4690783629713584
R605 6 5 0.6273799994756218
R700 7 0 0.8261301146349126
R701 7 1 1.0998769460388123
R702 7 2 1.052493386123596
R703 7 3 0.4278484374981948
R704 7 4 0.5767307940348919
R705 7 5 1.4528482333297577
R706 7 6 0.5460099566065255
R800 8 0 1.1219373193366202
R801 8 1 0.8769585657695601
R802 8 2 1.2112342980301052
R803 8 3 1.3682941420328467
R804 8 4 1.1733876524815892
R805 8 5 1.3497504086819083
R806 8 6 1.3286088186872334
R807 8 7 0.9567684115177613
R900 9 0 1.3119414129879086
R901 9 1 0.34618039578523396
R902 9 2 1.3942045647047827
R903 9 3 0.550514525878311
R904 9 4 0.051337667043606316
R905 9 5 1.2470721208209348
R906 9 6 0.864234752815017
R907 9 7 0.9296565598812416
R908 9 8 1.9538331770141595
R1000 10 0 0.9185103752495752
R1001 10 1 1.0719436698844729
R1002 10 2 1.0981545126836092
R1003 10 3 0.8836111000408168
R1004 10 4 1.141370355608178
R1005 10 5 0.7989129881480912
R1006 10 6 1.3526012794056315
R1007 10 7 1.5774334491402846
R1008 10 8 1.3462410246686942
R1009 10 9 1.3759793444488402
R1100 11 0 0.9218974796469402
R1101 11 1 1.3306293467765646
R1102 11 2 1.006561366251852
R1103 11 3 0.704754947314692
R1104 11 4 1.943279742070696
R1105 11 5 0.741617257062995
R1106 11 6 1.4320728764050865
R1107 11 7 0.6602484960120276
R1108 11 8 0.4260338503083796
R1109 11 9 1.3660526145776433
R1110 11 10 1.6110920515695457
R1200 12 0 1.6012927759099669
R1201 12 1 0.22140989038800163
R1202 12 2 0.6942343877164435
R1203 12 3 1.4229638445005888
R1204 12 4 0.49539618861246015
R1205 12 5 0.9296887339391596
R1206 12 6 0.22162526874422495
R1207 12 7 1.215055084658039
R1208 12 8 1.815679462535133
R1209 12 9 1.0107953330243844
R1210 12 10 1.3583898759027888
R1211 12 11 0.8536706629649223
R1300 13 0 1.8917551274522304
R1301 13 1 1.3152436124208537
R1302 13 2 1.107577527801456
R1303 13 3 0.7239275925965774
R1304 13 4 0.6636136097086704
R1305 13 5 0.4523340673075731
R1306 13 6 1.0993395339479246
R1307 13 7 0.698976840065008
R1308 13 8 0.8790186711042985
R1309 13 9 0.8829696302456782
R1310 13 10 0.24975535445129138
R1311 13 11 0.763969323767907
R1312 13 12 0.4649182583955387
R1400 14 0 0.49622640038776644
R1401 14 1 0.7721738778685766
R1402 14 2 1.1781296736451434
R1403 14 3 1.0812045779676325
R1404 14 4 0.31561892199836217
R1405 14 5 1.0211400371415942
R1406 14 6 0.4780190683102825
R1407 14 7 0.6501606000729327
R1408 14 8 1.2280852729859877
R1409 14 9 0.7809672112023814
R1410 14 10 1.610375244860798
R1411 14 11 1.16803624608466
R1412 14 12 0.9416307961639535
R1413 14 13 1.190650784248572
R1500 15 0 1.178835880224808
R1501 15 1 0.8806339744354329
R1502 15 2 0.7995341274748403
R1503 15 3 0.39208360632312667
R1504 15 4 1.4877252482210985
R1505 15 5 0.8124588589982947
R1506 15 6 0.7060105661254139
R1507 15 7 1.0219954489611782
R1508 15 8 0.4341956556256934
R1509 15 9 1.2191291392644008
R1510 15 10 0.5450199781936429
R1511 15 11 0.5549011442091718
R1512 15 12 1.2826195055587082
R1513 15 13 1.1347311140602745
R1514 15 14 0.8117150824647944
R1600 16 0 0.8163815342666125
R1601 16 1 0.7360445207967542
R1602 16 2 1.3464213409906955
R1603 16 3 1.5595292784111656
R1604 16 4 0.9757071605466788
R1605 16 5 1.296521762819024
R1606 16 6 0.8306206319082735
R1607 16 7 1.4945393940872846
R1608 16 8 0.5300887487347361
R1609 16 9 1.2390273556609128
R1610 16 10 0.9934828760921123
R1611 16 11 1.1016655497680499
R1612 16 12 0.9578360393020589
R1613 16 13 1.0640512419020434
R1614 16 14 1.1618547468654423
R1615 16 15 1.1727386176120078
R1700 17 0 1.0733272225495076
R1701 17 1 0.32975518232905765
R1702 17 2 0.8943413100706513
R1703 17 3 0.7010965618150271
R1704 17 4 0.9938843886280978
R1705 17 5 1.8504690040427632
R1706 17 6 0.48552638110795465
R1707 17 7 0.5125463314110005
R1708 17 8 0.4071482168589676
R1709 17 9 0.645086551022801
R1710 17 10 0.9277224689161735
R1711 17 11 1.143750519542893
R1712 17 12 0.6188826406053439
R1713 17 13 0.4615262518345119
R1714 17 14 1.307484744053426
R1715 17 15 1.709885850663033
R1716 17 16 0.582679364423807
R1800 18 0 1.4525798224892494
R1801 18 1 0.9447067962709518
R1802 18 2 1.3432865244039642
R1803 18 3 1.3825503583052277
R1804 18 4 1.056271803088726
R1805 18 5 0.5516454276057251
R1806 18 6 0.6829306260330916
R1807 18 7 0.912131702857055
R1808 18 8 0.0402979974117903
R1809 18 9 0.656219689296222
R1810 18 10 0.8667842535031901
R1811 18 11 1.037688433637103
R1812 18 12 0.6504185692178039
R1813 18 13 1.2808690452902836
R1814 18 14 0.8951828195163538
R1815 18 15 1.0074181337058707
R1816 18 16 1.2775400025388142
R1817 18 17 0.8558738861600553
R1900 19 0 1.4400881602681395
R1901 19 1 1.2168917707901055
R1902 19 2 1.086202614604058
R1903 19 3 1.3493624920255853
R1904 19 4 1.5589238509569805
R1905 19 5 0.9293760076979019
R1906 19 6 1.1048843684609837
R1907 19 7 0.7337494094364486
R1908 19 8 0.9734248109884113
R1909 19 9 1.2925702439644555
R1910 19 10 0.6651551211326627
R1911 19 11 0.6534036841538264
R1912 19 12 0.7435313471644408
R1913 19 13 0.274254347736291
R1914 19 14 1.7011202317109992
R1915 19 15 0.8047109624309161
R1916 19 16 1.1219034055178323
R1917 19 17 0.5553389889064321
R1918 19 18 1.312371635122373
R2000 20 0 0.4559923987464143
R2001 20 1 0.13257659900356478
R2002 20 2 0.7546468723267967
R2003 20 3 0.8947859052681828
R2004 20 4 1.2191154794107357
R2005 20 5 0.8751690481737953
R2006 20 6 1.5406066413234623
R2007 20 7 1.0845441913117602
R2008 20 8 1.4615813799903652
R2009 20 9 1.2196354587201639
R2010 20 10 0.8651498311512532
R2011 20 11 0.9943823677574517
R2012 20 12 0.48463723198973774
R2013 20 13 0.773100866208529
R2014 20 14 1.4157620940139042
R2015 20 15 0.9352282718081417
R2016 20 16 0.9450036214763294
R2017 20 17 0.6197568851921705
R2018 20 18 0.8362233003555299
R2019 20 19 1.3736354835322913
R2100 21 0 1.1333907112219501
R2101 21 1 0.6232715682204756
R2102 21 2 1.8172737884508474
R2103 21 3 0.7388493193323161
R2104 21 4 0.9782744960058913
R2105 21 5 0.5823396792577219
R2106 21 6 0.8546892613039543
R2107 21 7 0.7448234710253955
R2108 21 8 0.962912765689438
R2109 21 9 1.941141812648112
R2110 21 10 0.9745235950063225
R2111 21 11 1.5329673035436089
R2112 21 12 0.6499128180653628
R2113 21 13 1.3234933976975212
R2114 21 14 0.6828717999250382
R2115 21 15 0.9826703538156438
R2116 21 16 1.18709063140451
R2117 21 17 0.7720158932889287
R2118 21 18 1.163062549198782
R2119 21 19 1.8090677228368417
R2120 21 20 1.6035768125450263
R2200 22 0 0.5212402858244974
R2201 22 1 1.0116163661062436
R2202 22 2 0.5300953164983272
R2203 22 3 1.2570713003754599
R2204 22 4 1.1727129253500335
R2205 22 5 0.9359068438541349
R2206 22 6 0.5695611045451046
R2207 22 7 1.2767002894503787
R2208 22 8 0.8871985387093507
R2209 22 9 1.2993154342289657
R2210 22 10 1.2442733278221931
R2211 22 11 1.2091704704632824
R2212 22 12 1.2030687214921731
R2213 22 13 1.0960885114534045
R2214 22 14 1.265286218869674
R2215 22 15 1.3411973320200687
R2216 22 16 0.9606746316737312
R2217 22 17 1.0857432073761797
R2218 22 18 1.027576597917542
R2219 22 19 1.520480359580953
R2220 22 20 1.2323644540056113
R2221 22 21 0.8248087859226272
R2300 23 0 0.6207391097149211
R2301 23 1 0.24634430704470833
R2302 23 2 0.5524633736293902
R2303 23 3 0.5091908795082218
R2304 23 4 0.4866874236648405
R2305 23 5 0.19170705367614171
R2306 23 6 1.679575123287099
R2307 23 7 0.6575072524943847
R2308 23 8 0.5292890503775404
R2309 23 9 0.6230495153221159
R2310 23 10 0.6916450747981243
R2311 23 11 1.2990639737077467
R2312 23 12 1.152283287472263
R2313 23 13 1.0634842202286197
R2314 23 14 0.9759940674576079
R2315 23 15 1.03338439444319
R2316 23 16 1.434681145798587
R2317 23 17 1.309200657865374
R2318 23 18 1.5015984344730966
R2319 23 19 0.713842292636898
R2320 23 20 1.5374436260306896
R2321 23 21 0.7526783104092071
R2322 23 22 1.092986072583117
R2400 24 0 1.1510838096119764
R2401 24 1 1.1548652187616835
R2402 24 2 0.9938277621898619
R2403 24 3 1.0210512268686764
R2404 24 4 1.2634137989742205
R2405 24 5 1.1309171295626883
R2406 24 6 0.6295299903632078
R2407 24 7 1.7185788957544355
R2408 24 8 0.49583622832888996
R2409 24 9 1.1359056191229329
R2410 24 10 1.4039272942903316
R2411 24 11 1.7409361818084956
R2412 24 12 1.008125190487971
R2413 24 13 1.2874216682480382
R2414 24 14 0.36236040803509206
R2415 24 15 0.41374201410868294
R2416 24 16 1.08381006571476
R2417 24 17 0.5231095539873322
R2418 24 18 1.3279739721860055
R2419 24 19 0.9783404157873188
R2420 24 20 0.5265365577085048
R2421 24 21 0.9262169116395947
R2422 24 22 1.4363569998261125
R2423 24 23 1.0769081177965576
R2500 25 0 1.2845121039533582
R2501 25 1 1.4123593867213748
R2502 25 2 1.1431769252598083
R2503 25 3 1.4158494347452302
R2504 25 4 0.5329813313779731
R2505 25 5 1.0158034471938007
R2506 25 6 1.873090372737805
R2507 25 7 1.3523466655121386
R2508 25 8 0.6179557054375984
R2509 25 9 1.4690615867869345
R2510 25 10 1.4329248484223358
R2511 25 11 0.8294387761689963
R2512 25 12 0.7593887163132987
R2513 25 13 1.1787243081308085
R2514 25 14 1.8674746759677099
R2515 25 15 0.381082785875533
R2516 25 16 1.11971525861169
R2517 25 17 1.025901239704618
R2518 25 18 1.1132622250360535
R2519 25 19 1.593084991730009
R2520 25 20 1.0164544686695502
R2521 25 21 0.8052455755708684
R2522 25 22 1.509790357545401
R2523 25 23 0.4168394375036337
R2524 25 24 1.2593352892738818
R2600 26 0 0.8302660304019821
R2601 26 1 0.2652389251646503
R2602 26 2 1.6666651251613127
R2603 26 3 0.65908455630053
R2604 26 4 0.9682512449755498
R2605 26 5 1.0374104206612076
R2606 26 6 0.9806659972021045
R2607 26 7 1.4388105658721768
R2608 26 8 1.4284320684690246
R2609 26 9 0.6824434255075797
R2610 26 10 1.1735769959878424
R2611 26 11 0.9272469325117969
R2612 26 12 0.8756991713179576
R2613 26 13 0.9167883922563591
R2614 26 14 1.8413874066144555
R2615 26 15 1.5569221454197284
R2616 26 16 1.200295971349286
R2617 26 17 0.7203310573667541
R2618 26 18 1.5565015053280922
R2619 26 19 1.1147794598505767
R2620 26 20 0.5618221421981819
R2621 26 21 0.5031810760397328
R2622 26 22 0.8003514936808082
R2623 26 23 1.0993369059697518
R2624 26 24 0.8910738466401273
R2625 26 25 0.5195298668683235
R2700 27 0 1.9657771026373654
R2701 27 1 1.24511990180449
R2702 27 2 0.659645177210802
R2703 27 3 0.7443930798905141
R2704 27 4 0.17966589515695164
R2705 27 5 1.3369377387501236
R2706 27 6 1.4996079678615217
R2707 27 7 1.5160175301423586
R2708 27 8 0.9605049928035794
R2709 27 9 1.5699904523372399
R2710 27 10 0.533884936394317
R2711 27 11 1.298358048588703
R2712 27 12 0.1824391029052871
R2713 27 13 0.9882870070962351
R2714 27 14 1.2041399954108951
R2715 27 15 0.9841470663066496
R2716 27 16 0.17568987870900887
R2717 27 17 1.3452007528885583
R2718 27 18 1.0365606344807399
R2719 27 19 0.3045647291330501
R2720 27 20 0.9877596396396381
R2721 27 21 1.3550462139639294
R2722 27 22 0.948117493697745
R2723 27 23 1.6825371220868954
R2724 27 24 0.38047710254707134
R2725 27 25 0.4947492442216629
R2726 27 26 1.43346049069417
R2800 28 0 1.2499771288921961
R2801 28 1 1.0008155359807784
R2802 28 2 1.6563634894552184
R2803 28 3 1.2621456684117665
R2804 28 4 1.0631500685218975
R2805 28 5 0.34083910725200584
R2806 28 6 1.3193074942848106
R2807 28 7 0.9249887282637062
R2808 28 8 1.1219845008432887
R2809 28 9 0.6333258871824337
R2810 28 10 0.3159097936538685
R2811 28 11 0.30618316629738596
R2812 28 12 0.8589375990857125
R2813 28 13 1.4689058233117933
R2814 28 14 0.328872513230527
R2815 28 15 0.7437855795869973
R2816 28 16 1.7470247750552164
R2817 28 17 0.7423710296441115
R2818 28 18 0.4327700445623396
R2819 28 19 1.1412046143688084
R2820 28 20 0.5235860802868472
R2821 28 21 1.047369313622153
R2822 28 22 1.415778920334688
R2823 28 23 1.0957806938297083
R2824 28 24 1.1914762998254793
R2825 28 25 0.9578212094659211
R2826 28 26 1.2831375438404862
R2827 28 27 1.6743608298858068
R2900 29 0 0.3668759328518053
R2901 29 1 0.9017906542895019
R2902 29 2 0.8249823256012919
R2903 29 3 0.5711939027162241
R2904 29 4 0.9347151425919865
R2905 29 5 0.974056225715405
R2906 29 6 0.8480208548023908
R2907 29 7 0.959434112629216
R2908 29 8 1.0085359343079405
R2909 29 9 0.22910932304992693
R2910 29 10 1.0690784672248044
R2911 29 11 1.6387451149963626
R2912 29 12 0.7264719834119784
R2913 29 13 1.080220421489129
R2914 29 14 1.1066742410967274
R2915 29 15 0.190856443873605
R2916 29 16 0.48599744550422963
R2917 29 17 0.5977921642861583
R2918 29 18 0.8199608774260293
R2919 29 19 0.8342959787794959
R2920 29 20 1.0219329244127504
R2921 29 21 1.8658103275356634
R2922 29 22 0.81832282391355
R2923 29 23 1.4629505450627747
R2924 29 24 1.2748433798991443
R2925 29 25 0.634303148175248
R2926 29 26 1.1097510439015275
R2927 29 27 0.693270489298305
R2928 29 28 0.3811624686970495
R3000 30 0 0.9955300981307571
R3001 30 1 1.1478943080608328
R3002 30 2 1.6431989561667621
R3003 30 3 1.2944424935247025
R3004 30 4 0.7795548104969691
R3005 30 5 0.800823245737531
R3006 30 6 0.3070301281268927
R3007 30 7 1.1839635734649683
R3008 30 8 1.3588007232253405
R3009 30 9 1.3352381718565176
R3010 30 10 0.7194392507550083
R3011 30 11 0.38821094361827424
R3012 30 12 1.425360817013909
R3013 30 13 0.1583766499110587
R3014 30 14 0.7345655403101036
R3015 30 15 1.0079150381808581
R3016 30 16 0.07956743591572879
R3017 30 17 1.1021455761721581
R3018 30 18 0.7508281797084801
R3019 30 19 1.7733954182176377
R3020 30 20 0.6947306537911906
R3021 30 21 0.9998867686355588
R3022 30 22 1.1862211465424737
R3023 30 23 1.4180364355033408
R3024 30 24 0.8386942622924565
R3025 30 25 1.0426007711083844
R3026 30 26 1.1056813289709275
R3027 30 27 0.5367450476254448
R3028 30 28 0.9107572504551237
R3029 30 29 0.5371680252085919
R3100 31 0 1.394379222761724
R3101 31 1 1.1226630932453459
R3102 31 2 0.6940114412464297
R3103 31 3 0.9757993675485245
R3104 31 4 1.3042888709321732
R3105 31 5 0.7202745146795883
R3106 31 6 1.1056915882602931
R3107 31 7 0.9805220366919817
R3108 31 8 1.0558460229415594
R3109 31 9 1.2802508747790786
R3110 31 10 1.0456568541545992
R3111 31 11 1.0707685575241859
R3112 31 12 0.9047587290678375
R3113 31 13 0.9518206776767691
R3114 31 14 0.4466717276485874
R3115 31 15 1.4046037926014316
R3116 31 16 1.0084724006845933
R3117 31 17 0.8636553955067133
R3118 31 18 0.37228787365238447
R3119 31 19 1.4893543248212926
R3120 31 20 1.4351806754046317
R3121 31 21 1.0885066164947799
R3122 31 22 0.7977562022260656
R3123 31 23 1.4860756253568967
R3124 31 24 0.3905943037417565
R3125 31 25 0.17353760273717567
R3126 31 26 1.1060249572244008
R3127 31 27 0.5602363699716149
R3128 31 28 0.336190527091627
R3129 31 29 1.0322504595353201
R3130 31 30 1.6601968171703971
R3200 32 0 0.7919842410152337
R3201 32 1 0.5222686452704706
R3202 32 2 1.8928836826339743
R3203 32 3 0.5433950840603553
R3204 32 4 0.9677265261932778
R3205 32 5 1.3448502038788472
R3206 32 6 0.4506137569886406
R3207 32 7 0.5817578752913743
R3208 32 8 0.7497987283938841
R3209 32 9 1.548140784909278
R3210 32 10 1.2170865787940526
R3211 32 11 0.782590518751746
R3212 32 12 1.6333461279122703
R3213 32 13 1.408864988929316
R3214 32 14 1.3593457048185855
R3215 32 15 0.12187150184900097
R3216 32 16 1.0225881516704254
R3217 32 17 1.4686110223275568
R3218 32 18 1.4719587019781066
R3219 32 19 1.2914428698232452
R3220 32 20 1.016514252858474
R3221 32 21 1.3739225616315611
R3222 32 22 0.6646808074322538
R3223 32 23 0.7096400154511713
R3224 32 24 1.4261874441977063
R3225 32 25 0.8137651840539064
R3226 32 26 1.4332067182116923
R3227 32 27 0.9864825975227468
R3228 32 28 0.6395762665629965
R3229 32 29 1.0881866150446282
R3230 32 30 1.408209333831659
R3231 32 31 0.621335649760917
R3300 33 0 0.735872295266006
R3301 33 1 1.7435661764231098
R3302 33 2 0.9365581322273006
R3303 33 3 1.4826771440998863
R3304 33 4 1.8189391854917618
R3305 33 5 0.9811358572877007
R3306 33 6 0.9448955625014036
R3307 33 7 0.6062616326179273
R3308 33 8 0.3893028782000396
R3309 33 9 1.623005137441594
R3310 33 10 0.7176869320482746
R3311 33 11 1.311367034295532
R3312 33 12 0.6050531015508186
R3313 33 13 0.9143971550727219
R3314 33 14 0.9145221956019581
R3315 33 15 1.19942490118212
R3316 33 16 0.3092731625548435
R3317 33 17 0.8831251693876507
R3318 33 18 0.6905469788409995
R3319 33 19 1.086530082851386
R3320 33 20 0.8409724014503973
R3321 33 21 1.7084366060996836
R3322 33 22 0.11473491227611066
R3323 33 23 0.699138278903786
R3324 33 24 1.0934969093366198
R3325 33 25 0.8128005865637493
R3326 33 26 1.0653474014091264
R3327 33 27 0.658774569800487
R3328 33 28 0.3245338517241121
R3329 33 29 0.28586835945698197
R3330 33 30 0.43121448233033643
R3331 33 31 0.8898849499710862
R3332 33 32 1.1173391806586728
R3400 34 0 0.5347440697042372
R3401 34 1 1.7671222492570244
R3402 34 2 1.0105014456778676
R3403 34 3 1.0646109884791903
R3404 34 4 1.4069295185699047
R3405 34 5 0.8382664101974858
R3406 34 6 0.5158193074477077
R3407 34 7 1.745346560895602
R3408 34 8 0.9632198084229363
R3409 34 9 1.2341631405951632
R3410 34 10 1.277835797738327
R3411 34 11 1.0240071990264799
R3412 34 12 1.0242281972642813
R3413 34 13 1.8978935284254654
R3414 34 14 0.7959880806935111
R3415 34 15 1.0186255511389335
R3416 34 16 1.3278920926477136
R3417 34 17 1.3596444974503454
R3418 34 18 1.1625082453931217
R3419 34 19 1.624168825024293
R3420 34 20 1.9335945488707016
R3421 34 21 1.3010772348608297
R3422 34 22 1.2831436891774728
R3423 34 23 1.1061216993531522
R3424 34 24 0.827498416150793
R3425 34 25 1.1657716687816408
R3426 34 26 0.9249272690584445
R3427 34 27 1.107377872700535
R3428 34 28 1.6482020337305685
R3429 34 29 1.9485120888603817
R3430 34 30 0.3205157180545226
R3431 34 31 0.7528144576540553
R3432 34 32 0.24318577455394974
R3433 34 33 0.5966603785095463
R3500 35 0 0.9491463231186485
R3501 35 1 0.48960561559519244
R3502 35 2 1.5513625214872129
R3503 35 3 0.8375929512329291
R3504 35 4 1.3626025240790995
R3505 35 5 0.4793210809010148
R3506 35 6 0.6266795940907536
R3507 35 7 1.4009608678645302
R3508 35 8 1.0375696617547843
R3509 35 9 0.6436219002463507
R3510 35 10 0.9330738133626982
R3511 35 11 1.2958523396270087
R3512 35 12 0.9993301889368714
R3513 35 13 1.67227508459027
R3514 35 14 0.6158418946937634
R3515 35 15 1.0006832148507283
R3516 35 16 1.4030723427997667
R3517 35 17 0.484719433689765
R3518 35 18 1.1407933532051413
R3519 35 19 1.2446573996618842
R3520 35 20 0.9805891125779455
R3521 35 21 1.6730265600523138
R3522 35 22 1.1077829114140774
R3523 35 23 0.47099302681753086
R3524 35 24 1.4823852137122375
R3525 35 25 0.6752086686338797
R3526 35 26 1.2906825361378127
R3527 35 27 1.4009661462080287
R3528 35 28 1.455146062505153
R3529 35 29 1.5853548573188876
R3530 35 30 1.1236403450141261
R3531 35 31 0.47441584853913565
R3532 35 32 1.8848139331000366
R3533 35 33 1.0409922283983484
R3534 35 34 0.6165730119876631
R3600 36 0 1.9669915185998652
R3601 36 1 1.544300612202393
R3602 36 2 0.3565961412368882
R3603 36 3 0.9463010417317936
R3604 36 4 0.8552280849308133
R3605 36 5 0.7952524809834501
R3606 36 6 0.8683497587959411
R3607 36 7 0.8261948042717296
R3608 36 8 1.159412864223
R3609 36 9 1.180405128215392
R3610 36 10 1.1375125269377386
R3611 36 11 1.6796998019233151
R3612 36 12 1.0164251565354814
R3613 36 13 0.9630513952048103
R3614 36 14 1.0122395291799813
R3615 36 15 0.64736249118669
R3616 36 16 0.533908613079976
R3617 36 17 1.2375035532723047
R3618 36 18 1.1602382855168718
R3619 36 19 0.6966946878594789
R3620 36 20 0.8523998789523038
R3621 36 21 1.1697931578314298
R3622 36 22 0.5375588145329027
R3623 36 23 1.6732737736846697
R3624 36 24 0.5719195000651017
R3625 36 25 0.7326581955117398
R3626 36 26 1.0661208324035982
R3627 36 27 1.4304635969104424
R3628 36 28 0.6418940643068755
R3629 36 29 0.552673304775866
R3630 36 30 0.8484403013986771
R3631 36 31 0.7456287884239418
R3632 36 32 1.010536135669304
R3633 36 33 0.6783995439402042
R3634 36 34 0.8962518881989276
R3635 36 35 1.2226215430634935
R3700 37 0 0.6323080785268561
R3701 37 1 1.3183580864402502
R3702 37 2 1.5339637787626343
R3703 37 3 0.922119170042763
R3704 37 4 0.8009665857637149
R3705 37 5 0.6751880774244423
R3706 37 6 0.24478104569376424
R3707 37 7 1.7895215405704241
R3708 37 8 1.136085461656588
R3709 37 9 1.1223497048380564
R3710 37 10 1.1953728343235497
R3711 37 11 1.436771045895676
R3712 37 12 1.3071219759968553
R3713 37 13 0.08915960169156689
R3714 37 14 0.8994538758701175
R3715 37 15 1.2996992547633615
R3716 37 16 0.40950558201158926
R3717 37 17 1.0789159902384524
R3718 37 18 0.941654962914798
R3719 37 19 1.152038077364825
R3720 37 20 0.23461133068912
R3721 37 21 0.39596938034989526
R3722 37 22 1.2347138069471075
R3723 37 23 1.4589683871703854
R3724 37 24 1.155425211689994
R3725 37 25 1.1259545091499237
R3726 37 26 0.9144661304350391
R3727 37 27 0.273983336441456
R3728 37 28 0.868850866206797
R3729 37 29 0.5084432415750312
R3730 37 30 1.2213340167836235
R3731 37 31 1.0130986486379077
R3732 37 32 1.9102982207266894
R3733 37 33 1.0714138392757384
R3734 37 34 1.0961609455093555
R3735 37 35 0.263209869375552
R3736 37 36 1.2919996608888384
R3800 38 0 0.7287426240371023
R3801 38 1 0.977987061877832
R3802 38 2 1.1914757063938386
R3803 38 3 1.3702293776640402
R3804 38 4 0.35079010676000666
R3805 38 5 1.2977369697260266
R3806 38 6 1.1444529001378632
R3807 38 7 0.9579264866033501
R3808 38 8 1.3817487854057078
R3809 38 9 1.451822690432071
R3810 38 10 1.0389049220207212
R3811 38 11 0.4185966564458484
R3812 38 12 1.3962353065797846
R3813 38 13 0.9206788093907893
R3814 38 14 0.8160168890342714
R3815 38 15 0.33902373383265116
R3816 38 16 0.9121000296859901
R3817 38 17 0.9298684173598162
R3818 38 18 1.5295706333526344
R3819 38 19 0.8664542576407858
R3820 38 20 1.729518178303349
R3821 38 21 1.286369520894311
R3822 38 22 1.350591327649867
R3823 38 23 0.8112513774494253
R3824 38 24 1.1843269044450715
R3825 38 25 0.2633061737929048
R3826 38 26 0.9999025023731938
R3827 38 27 1.526430229754455
R3828 38 28 0.865749209199872
R3829 38 29 1.4457960087783301
R3830 38 30 1.5479916840145316
R3831 38 31 1.8469710506038637
R3832 38 32 1.5905339191244772
R3833 38 33 0.8294831375251878
R3834 38 34 1.2356819195048359
R3835 38 35 1.4348409158688398
R3836 38 36 1.7781455296748048
R3837 38 37 0.9926549540940307
R3900 39 0 0.9576277202220494
R3901 39 1 0.8645333679580559
R3902 39 2 1.3366903531984913
R3903 39 3 0.6975694711622714
R3904 39 4 1.0073747483032942
R3905 39 5 1.6956063792506295
R3906 39 6 0.4022506811812616
R3907 39 7 1.2890453469187708
R3908 39 8 1.1022945848827654
R3909 39 9 0.9391474177579369
R3910 39 10 1.418105307681405
R3911 39 11 0.9865278183648937
R3912 39 12 1.2250461127772554
R3913 39 13 0.8450634278557544
R3914 39 14 0.8779746181232414
R3915 39 15 1.7953073388528846
R3916 39 16 0.7001347812074842
R3917 39 17 0.7070369425739793
R3918 39 18 0.9472370680061087
R3919 39 19 0.5399771931585687
R3920 39 20 1.493787149466809
R3921 39 21 1.4132155511500293
R3922 39 22 1.2252785810452909
R3923 39 23 1.0970649635029015
R3924 39 24 0.5913769658787705
R3925 39 25 1.1227718100506174
R3926 39 26 1.3673174954236567
R3927 39 27 1.0549964029123342
R3928 39 28 1.2440766293794734
R3929 39 29 1.1764423898590317
R3930 39 30 1.539877755968162
R3931 39 31 0.880219491182556
R3932 39 32 1.2478747005047592
R3933 39 33 1.1246785471520897
R3934 39 34 0.36187359331053515
R3935 39 35 1.4410582247876969
R3936 39 36 1.1640968455466068
R3937 39 37 0.5720822029380959
R3938 39 38 0.7395244350020691
R4000 40 0 1.3713836400924582
R4001 40 1 0.2502573152822587
R4002 40 2 0.5768420603308874
R4003 40 3 0.5021723550386494
R4004 40 4 1.1271811299618502
R4005 40 5 1.1640849299353973
R4006 40 6 1.4275701913296617
R4007 40 7 1.4588123278437726
R4008 40 8 0.2940815840453802
R4009 40 9 1.3766837158509078
R4010 40 10 1.2602885627924865
R4011 40 11 1.148422272594602
R4012 40 12 0.8409675180231542
R4013 40 13 1.5002670681035495
R4014 40 14 0.6666677864312424
R4015 40 15 0.864456316582617
R4016 40 16 0.3385038249736315
R4017 40 17 0.8483366733369823
R4018 40 18 0.8041622729949418
R4019 40 19 1.2796928513227237
R4020 40 20 0.6763918727809525
R4021 40 21 0.6748171812348445
R4022 40 22 1.2408952022213664
R4023 40 23 0.564060938249941
R4024 40 24 0.6087134568403759
R4025 40 25 1.4598487037691703
R4026 40 26 0.4405071476707153
R4027 40 27 1.1726685879233036
R4028 40 28 1.4448153000153479
R4029 40 29 0.1451117206162944
R4030 40 30 1.6595973827908228
R4031 40 31 0.9099322349265162
R4032 40 32 0.7037508597952535
R4033 40 33 0.692366120652425
R4034 40 34 1.0687014543402968
R4035 40 35 0.5912872821992073
R4036 40 36 1.1879151960777095
R4037 40 37 1.658546699768953
R4038 40 38 0.5667817141986095
R4039 40 39 0.236748789342347
R4100 41 0 0.20000768717493567
R4101 41 1 1.563264459424007
R4102 41 2 0.8505653036601162
R4103 41 3 1.5572097762903718
R4104 41 4 0.41712263675370054
R4105 41 5 0.39088536897257997
R4106 41 6 1.4391247818685309
R4107 41 7 1.218609280426263
R4108 41 8 0.5455416004569905
R4109 41 9 1.175420036918533
R4110 41 10 0.7377318920174356
R4111 41 11 1.4299086935659835
R4112 41 12 0.2572116461398264
R4113 41 13 0.9543273219681666
R4114 41 14 1.5136242479993367
R4115 41 15 0.26804970759155533
R4116 41 16 0.9440237036610954
R4117 41 17 1.3153982197035479
R4118 41 18 1.214154001425494
R4119 41 19 0.23510132828803798
R4120 41 20 0.009439556916758352
R4121 41 21 1.1616044100161882
R4122 41 22 0.7586449593405904
R4123 41 23 1.330009149836107
R4124 41 24 1.7315902444336317
R4125 41 25 0.6092749328178516
R4126 41 26 0.9954718569840769
R4127 41 27 1.3480750528535657
R4128 41 28 1.0125818843013956
R4129 41 29 0.4592199499950643
R4130 41 30 0.8336953200262356
R4131 41 31 1.0836519108455542
R4132 41 32 1.6400218679361216
R4133 41 33 1.072293994661652
R4134 41 34 0.6964535612029081
R4135 41 35 1.3360174708543928
R4136 41 36 1.5803637087841642
R4137 41 37 0.7370796347513056
R4138 41 38 0.8688638387596922
R4139 41 39 0.76787856927687
R4140 41 40 1.1109800280002258
R4200 42 0 0.9075598943192544
R4201 42 1 0.27084291736957733
R4202 42 2 1.0438872596510338
R4203 42 3 0.3673667244099278
R4204 42 4 1.2280871466107555
R4205 42 5 1.1331914875712568
R4206 42 6 1.049864528841481
R4207 42 7 0.8963416761592196
R4208 42 8 1.1127044517580975
R4209 42 9 0.884154107670757
R4210 42 10 0.29156017783390675
R4211 42 11 1.233327856975631
R4212 42 12 1.115653406084713
R4213 42 13 1.545622578510359
R4214 42 14 0.5956893159754748
R4215 42 15 0.7540469101167308
R4216 42 16 1.5842694030746975
R4217 42 17 1.392050521127313
R4218 42 18 1.2428931853104679
R4219 42 19 0.9807545758769418
R4220 42 20 0.5626422182121393
R4221 42 21 0.4982332364865236
R4222 42 22 0.9538859805763955
R4223 42 23 0.6612099799816475
R4224 42 24 0.29937530470906126
R4225 42 25 0.6151023037572518
R4226 42 26 1.2348506663557641
R4227 42 27 0.3886534760923892
R4228 42 28 0.3695742435471604
R4229 42 29 1.164226615312422
R4230 42 30 0.977674234121491
R4231 42 31 1.192873005659533
R4232 42 32 0.47356489861714224
R4233 42 33 0.9739939958834356
R4234 42 34 1.3379234788445227
R4235 42 35 0.9402203483100559
R4236 42 36 1.487727374983594
R4237 42 37 1.3707412340688974
R4238 42 38 1.7176417402881905
R4239 42 39 1.0191458731930423
R4240 42 40 0.9500757322160991
R4241 42 41 0.8351206756588566
R4300 43 0 1.4566649076153335
R4301 43 1 1.0086154976468698
R4302 43 2 0.6414411748352252
R4303 43 3 0.970751560798973
R4304 43 4 1.7075759521482252
R4305 43 5 0.7804930952423722
R4306 43 6 0.5536760804358454
R4307 43 7 0.22283961369437277
R4308 43 8 0.8949102881011969
R4309 43 9 0.9755680211220357
R4310 43 10 0.4771490106230386
R4311 43 11 0.8040680065761844
R4312 43 12 0.6361231522787265
R4313 43 13 1.8022642412612797
R4314 43 14 0.5809880156471273
R4315 43 15 1.018054219978898
R4316 43 16 0.6399164089207384
R4317 43 17 0.5886353347743183
R4318 43 18 1.7003896650067403
R4319 43 19 0.992777414524502
R4320 43 20 0.8803710100411967
R4321 43 21 0.5698098083049175
R4322 43 22 1.554161698495494
R4323 43 23 1.05908575637729
R4324 43 24 0.6526271486540474
R4325 43 25 0.672411313244416
R4326 43 26 0.9876172317179084
R4327 43 27 1.4560273618589155
R4328 43 28 1.767397915084529
R4329 43 29 0.824536901143458
R4330 43 30 0.672361068326459
R4331 43 31 1.0230214778667976
R4332 43 32 0.5788475463205226
R4333 43 33 0.2903489233455153
R4334 43 34 0.9669350489069704
R4335 43 35 0.9124854335480815
R4336 43 36 1.0738740318410027
R4337 43 37 1.2805848382663778
R4338 43 38 0.5796947503936275
R4339 43 39 0.976658770235377
R4340 43 40 1.5209769652194862
R4341 43 41 0.9920330707961704
R4342 43 42 0.7642950610134231
R4400 44 0 1.3301985591521286
R4401 44 1 0.5846080414529161
R4402 44 2 0.5917806092193217
R4403 44 3 1.839090131046952
R4404 44 4 0.47315615370338593
R4405 44 5 0.7640629865503772
R4406 44 6 1.5259274945165355
R4407 44 7 0.4703194618592911
R4408 44 8 0.8402876580445235
R4409 44 9 1.1875826475141222
R4410 44 10 1.0065170510760226
R4411 44 11 1.5079576945225521
R4412 44 12 0.4984133453499435
R4413 44 13 1.3042926785121902
R4414 44 14 0.7724388151149157
R4415 44 15 0.773257803841948
R4416 44 16 1.3964624686131697
R4417 44 17 1.100512650053394
R4418 44 18 0.88413724314084
R4419 44 19 1.5034132510792348
R4420 44 20 0.33802726941755945
R4421 44 21 0.939854923554427
R4422 44 22 1.518707323323239
R4423 44 23 1.1645724510145765
R4424 44 24 0.7544861437661975
R4425 44 25 0.9518949844936009
R4426 44 26 0.6559199915394544
R4427 44 27 1.454724406253387
R4428 44 28 1.044980263326298
R4429 44 29 0.6950825798348057
R4430 44 30 1.1658711364334147
R4431 44 31 0.7095345778196047
R4432 44 32 0.37583033401778476
R4433 44 33 1.5744945145851066
R4434 44 34 0.925151701666479
R4435 44 35 1.6266562793808412
R4436 44 36 1.7864661288368113
R4437 44 37 1.0948744094262348
R4438 44 38 0.19425484838793017
R4439 44 39 1.0209243678512248
R4440 44 40 1.1950368338874044
R4441 44 41 0.9217205903531777
R4442 44 42 0.7330853854848963
R4443 44 43 1.375358511796652
R4500 45 0 1.4181047995613913
R4501 45 1 0.8326413277872796
R4502 45 2 1.3078914240024169
R4503 45 3 0.896207005992583
R4504 45 4 1.1556902670816855
R4505 45 5 0.340699734751027
R4506 45 6 0.9293389532207711
R4507 45 7 1.4390568247474964
R4508 45 8 1.1924654340408387
R4509 45 9 0.28237244792927463
R4510 45 10 1.4857538306082752
R4511 45 11 0.479519692784087
R4512 45 12 1.3614514967572942
R4513 45 13 1.3320352379435958
R4514 45 14 1.2971893260082215
R4515 45 15 1.2129524638272686
R4516 45 16 1.5807961384366462
R4517 45 17 0.048958051486703735
R4518 45 18 0.6514152049315874
R4519 45 19 0.17890780996221378
R4520 45 20 0.8411479104169023
R4521 45 21 1.4611059316654271
R4522 45 22 0.5623170124203329
R4523 45 23 1.6498672986276661
R4524 45 24 0.9070317351475503
R4525 45 25 1.564220681865661
R4526 45 26 0.7796594522497641
R4527 45 27 1.786926416853496
R4528 45 28 1.238054880620436
R4529 45 29 0.8280133471075687
R4530 45 30 1.670618957782139
R4531 45 31 0.8565103776322971
R4532 45 32 0.6425962477574167
R4533 45 33 0.8799691438316241
R4534 45 34 0.5980444365600748
R4535 45 35 1.0691952208062465
R4536 45 36 1.0846744330225713
R4537 45 37 0.7075718490652141
R4538 45 38 0.7726621194776296
R4539 45 39 1.4038014861775139
R4540 45 40 0.8584176481804234
R4541 45 41 1.7059076750274795
R4542 45 42 0.4761889541245986
R4543 45 43 0.6116781253995639
R4544 45 44 1.0497605912017482
R4600 46 0 1.2635534678636084
R4601 46 1 1.7905345387275182
R4602 46 2 0.2946153454821724
R4603 46 3 0.37570570397291625
R4604 46 4 0.49858838432011876
R4605 46 5 1.440701790017617
R4606 46 6 0.7187922496155085
R4607 46 7 1.2714675844785341
R4608 46 8 1.0851213776195334
R4609 46 9 0.5231418358461769
R4610 46 10 1.5708100284507287
R4611 46 11 1.4070339072733462
R4612 46 12 0.8289615827952603
R4613 46 13 0.859305456799412
R4614 46 14 1.3154736137131855
R4615 46 15 1.8126559778099018
R4616 46 16 1.4929854455900973
R4617 46 17 1.1449948719172607
R4618 46 18 0.5265210227416726
R4619 46 19 1.2876175487633925
R4620 46 20 0.829641108067051
R4621 46 21 0.8629713933402853
R4622 46 22 0.9203418399343936
R4623 46 23 0.3821569201669063
R4624 46 24 1.6114555666216173
R4625 46 25 1.2335671573222489
R4626 46 26 1.2098589371674153
R4627 46 27 1.36535239817667
R4628 46 28 1.111208465818049
R4629 46 29 1.7118085692962017
R4630 46 30 0.8881397546792568
R4631 46 31 1.0226181172615034
R4632 46 32 0.8542820453371525
R4633 46 33 1.2975217619500121
R4634 46 34 1.3582109566497316
R4635 46 35 1.9746735599988772
R4636 46 36 1.373170769547254
R4637 46 37 0.9120477388920005
R4638 46 38 1.0649303231442513
R4639 46 39 0.36420934724443343
R4640 46 40 0.6461698752164453
R4641 46 41 1.6288052107125408
R4642 46 42 1.3822256365491814
R4643 46 43 1.5277059779722668
R4644 46 44 1.4278277327200548
R4645 46 45 0.36361449880515206
R4700 47 0 1.4077349342922654
R4701 47 1 1.0132221484311954
R4702 47 2 0.9945426154530146
R4703 47 3 0.890730389014211
R4704 47 4 1.0323651558887748
R4705 47 5 1.7181586348472968
R4706 47 6 0.5578420844429104
R4707 47 7 0.9319156204090558
R4708 47 8 0.9240113287715966
R4709 47 9 1.155263360122243
R4710 47 10 0.4608854241740956
R4711 47 11 0.35536042974459126
R4712 47 12 0.802337535787524
R4713 47 13 0.6331971334859309
R4714 47 14 1.2089190127499303
R4715 47 15 1.3995286114683956
R4716 47 16 1.1599012161353786
R4717 47 17 1.0187014325059716
R4718 47 18 0.23461481730933242
R4719 47 19 0.8801581483357158
R4720 47 20 1.34075314791438
R4721 47 21 0.5229925720099425
R4722 47 22 0.7697117620943088
R4723 47 23 1.796825377853597
R4724 47 24 0.7094966542371727
R4725 47 25 1.5283780705646803
R4726 47 26 1.6374223855960417
R4727 47 27 0.6719042423623992
R4728 47 28 0.877099030674079
R4729 47 29 0.8571472443945092
R4730 47 30 1.3195572407237215
R4731 47 31 0.2916293576036463
R4732 47 32 1.3887946063873047
R4733 47 33 0.8165708097430942
R4734 47 34 1.0601539322343854
R4735 47 35 0.6596933499408651
R4736 47 36 1.147885074353744
R4737 47 37 1.2685490438440241
R4738 47 38 0.8337646375126985
R4739 47 39 0.3820353921992583
R4740 47 40 0.973660885352184
R4741 47 41 0.3201421496795539
R4742 47 42 0.6180955583204484
R4743 47 43 1.5494792963668216
R4744 47 44 0.692635578260048
R4745 47 45 1.2055700474386617
R4746 47 46 0.1290530938941441
R4800 48 0 1.6104131958475767
R4801 48 1 1.100090246883459
R4802 48 2 0.9372678062775074
R4803 48 3 1.1675895198543733
R4804 48 4 0.9302949932033716
R4805 48 5 0.5777082307062533
R4806 48 6 1.680882304785153
R4807 48 7 0.9171582038347803
R4808 48 8 0.7623879021430643
R4809 48 9 0.8173502810357343
R4810 48 10 1.3820268991709188
R4811 48 11 0.7454196156448049
R4812 48 12 0.5501253021031394
R4813 48 13 1.486031602947125
R4814 48 14 0.8539444250077551
R4815 48 15 0.9031313400791849
R4816 48 16 1.350549210341857
R4817 48 17 0.6419617641732519
R4818 48 18 0.9424061650318422
R4819 48 19 0.7680432037432058
R4820 48 20 1.1170942585416637
R4821 48 21 1.2665176726165637
R4822 48 22 0.402684302396087
R4823 48 23 1.3050308324439086
R4824 48 24 0.5641638824889162
R4825 48 25 1.1451212788457246
R4826 48 26 0.8948541894263431
R4827 48 27 1.541590964493099
R4828 48 28 1.7793835439141614
R4829 48 29 1.6902712509922162
R4830 48 30 1.1385235016199786
R4831 48 31 1.1093423979663601
R4832 48 32 0.8198555497768918
R4833 48 33 0.4688615851640847
R4834 48 34 1.7180344742090585
R4835 48 35 0.25980742243861243
R4836 48 36 1.1245259847499742
R4837 48 37 1.2811968532669127
R4838 48 38 0.9894300437346872
R4839 48 39 1.6450832139811227
R4840 48 40 0.35375646740102684
R4841 48 41 0.8159519526852678
R4842 48 42 0.7930757474738053
R4843 48 43 0.927205640494779
R4844 48 44 1.1222783550103217
R4845 48 45 1.2920152264407956
R4846 48 46 1.1773635813713812
R4847 48 47 0.6261725775933804
R4900 49 0 0.7914162038794601
R4901 49 1 1.8253081212202202
R4902 49 2 1.2436581394152961
R4903 49 3 0.8843103908946915
R4904 49 4 1.2370282366125318
R4905 49 5 0.8407187519892609
R4906 49 6 0.8567877912900557
R4907 49 7 0.9088922244725395
R4908 49 8 1.1032817038652967
R4909 49 9 0.9902077112785145
R4910 49 10 1.0553624618299242
R4911 49 11 0.3339623960521467
R4912 49 12 0.9211680656472173
R4913 49 13 0.9384993717663158
R4914 49 14 0.7635264215060659
R4915 49 15 1.3007547763787204
R4916 49 16 0.8204679551870254
R4917 49 17 1.721702526104378
R4918 49 18 1.1589113078873405
R4919 49 19 0.42947932301096625
R4920 49 20 1.4957567967304446
R4921 49 21 0.709642969681355
R4922 49 22 0.5907641229745242
R4923 49 23 0.7860595423241742
R4924 49 24 0.5144131457561859
R4925 49 25 0.7772716212641235
R4926 49 26 1.058310565770623
R4927 49 27 1.626696890391699
R4928 49 28 0.6078859766867077
R4929 49 29 1.1343198542595578
R4930 49 30 0.963225034726715
R4931 49 31 0.7761192375245787
R4932 49 32 0.5505785688382511
R4933 49 33 1.8369641464323485
R4934 49 34 0.8000918999910801
R4935 49 35 1.5118970072426028
R4936 49 36 1.1263714802142826
R4937 49 37 0.9934688852921113
R4938 49 38 0.7174436204999226
R4939 49 39 0.8446060397022405
R4940 49 40 0.7242023056683018
R4941 49 41 1.0870654947834861
R4942 49 42 0.9736817100820638
R4943 49 43 1.355800880358041
R4944 49 44 0.805802240876346
R4945 49 45 1.0495300417173206
R4946 49 46 0.8427698373884651
R4947 49 47 0.4839057515293613
R4948 49 48 1.1053774607796816
R5000 50 0 0.3732958783312905
R5001 50 1 0.5171729556371182
R5002 50 2 0.6259696094950711
R5003 50 3 1.2808581806672996
R5004 50 4 0.4249926512888538
R5005 50 5 0.4278392821955659
R5006 50 6 0.9384072092659238
R5007 50 7 0.4721178396495854
R5008 50 8 0.6923166136516513
R5009 50 9 0.9099070893653627
R5010 50 10 1.4221005645121847
R5011 50 11 0.5479925015346895
R5012 50 12 1.3760511237298867
R5013 50 13 1.1868807945025082
R5014 50 14 0.9528977734899343
R5015 50 15 1.167645490564937
R5016 50 16 1.0875529500626921
R5017 50 17 1.1936492062314166
R5018 50 18 0.7065379518972855
R5019 50 19 1.5011397887067655
R5020 50 20 1.7156225819812625
R5021 50 21 1.027658025557637
R5022 50 22 1.3889008017394047
R5023 50 23 0.8189665321702417
R5024 50 24 0.3341821878652206
R5025 50 25 0.6902220778410428
R5026 50 26 0.35707022484487405
R5027 50 27 0.8881340029803093
R5028 50 28 0.2373894311580157
R5029 50 29 1.2125138217049218
R5030 50 30 1.0029132755864771
R5031 50 31 0.6197812480232533
R5032 50 32 1.309020242090131
R5033 50 33 1.3080602546757993
R5034 50 34 0.8988149132076705
R5035 50 35 0.6006283654330957
R5036 50 36 1.8088277529208892
R5037 50 37 1.465432121906594
R5038 50 38 0.6090901855391017
R5039 50 39 1.0194902075882402
R5040 50 40 0.9890823981720528
R5041 50 41 1.220050571165657
R5042 50 42 0.08389689891450502
R5043 50 43 1.5183739845217485
R5044 50 44 0.5759706078781904
R5045 50 45 0.4227763645065702
R5046 50 46 0.35077780580981033
R5047 50 47 0.7832526556440028
R5048 50 48 1.9004808003404974
R5049 50 49 1.037397260599835
R5100 51 0 0.9682097299104093
R5101 51 1 1.1230689965565421
R5102 51 2 1.6401362653079232
R5103 51 3 0.18517245309831842
R5104 51 4 0.9888671692631005
R5105 51 5 0.9613536674864903
R5106 51 6 0.6199230893210466
R5107 51 7 1.0204132112861868
R5108 51 8 1.1259345509010434
R5109 51 9 0.3004825227997625
R5110 51 10 0.39756493455236397
R5111 51 11 1.034721919967574
R5112 51 12 0.7610610453656342
R5113 51 13 0.7062175213779188
R5114 51 14 1.6255642893104625
R5115 51 15 1.2623983783654846
R5116 51 16 0.9902364244964649
R5117 51 17 1.1917861089537345
R5118 51 18 0.9752583979139815
R5119 51 19 0.9949612459664344
R5120 51 20 0.2858030370286021
R5121 51 21 1.4740036027479508
R5122 51 22 0.9698959969182682
R5123 51 23 0.7640744782659314
R5124 51 24 0.9265292863539175
R5125 51 25 0.8031702641398174
R5126 51 26 0.5379583407771629
R5127 51 27 1.4361238966455216
R5128 51 28 1.432801123291641
R5129 51 29 0.17058346321798235
R5130 51 30 0.958970281460257
R5131 51 31 0.7196865404193182
R5132 51 32 0.39325636004553155
R5133 51 33 0.5224859292740942
R5134 51 34 1.0472517662816418
R5135 51 35 0.9722258640574173
R5136 51 36 0.6519324916730302
R5137 51 37 0.31822174743617804
R5138 51 38 1.0552606257044745
R5139 51 39 1.4125026202241067
R5140 51 40 0.6841138733519004
R5141 51 41 1.232938770509098
R5142 51 42 0.8262711506413969
R5143 51 43 1.3538196819607546
R5144 51 44 0.5873215229437285
R5145 51 45 0.9802981786857846
R5146 51 46 1.3714362229540926
R5147 51 47 0.7196998930300788
R5148 51 48 1.1522739216255373
R5149 51 49 0.48264036012119405
R5150 51 50 0.14245676000810925
R5200 52 0 1.6504155006035588
R5201 52 1 0.5086191049957716
R5202 52 2 0.14820332772080613
R5203 52 3 1.7490180903895238
R5204 52 4 1.3774281873400516
R5205 52 5 0.9544167738940441
R5206 52 6 0.27227656695101055
R5207 52 7 0.5188236169932309
R5208 52 8 1.3704673674083083
R5209 52 9 1.024050291179536
R5210 52 10 1.5933311383673954
R5211 52 11 1.2664075001062103
R5212 52 12 0.3750565249701583
R5213 52 13 1.854179528245354
R5214 52 14 1.2120331121365142
R5215 52 15 0.3389892788204808
R5216 52 16 0.25946065207422375
R5217 52 17 1.7583532564086912
R5218 52 18 0.3751818670772342
R5219 52 19 1.0549945786937271
R5220 52 20 1.817261900707991
R5221 52 21 1.2602644143843025
R5222 52 22 1.7592378304437428
R5223 52 23 1.1811619409737775
R5224 52 24 1.3902017503041884
R5225 52 25 1.006771976673324
R5226 52 26 1.231792735617058
R5227 52 27 0.9766009820077804
R5228 52 28 0.6340776002427836
R5229 52 29 1.0033154174395416
R5230 52 30 1.7142531735454856
R5231 52 31 1.8693161036668249
R5232 52 32 0.3799242489112121
R5233 52 33 1.536048532313591
R5234 52 34 0.8811284609030013
R5235 52 35 1.446429081192119
R5236 52 36 0.31685459217846346
R5237 52 37 1.3311995701861052
R5238 52 38 0.5604810288345253
R5239 52 39 0.7899825157963277
R5240 52 40 0.9469634595445774
R5241 52 41 1.3122106525630726
R5242 52 42 1.3522902195146074
R5243 52 43 1.2018364824240642
R5244 52 44 0.9536982589612073
R5245 52 45 1.2099606731913777
R5246 52 46 0.8836541118800222
R5247 52 47 0.8619071253920668
R5248 52 48 1.0152071679948214
R5249 52 49 1.5639338317983662
R5250 52 50 0.7721463480513593
R5251 52 51 0.7681342275320638
R5300 53 0 1.070265719206405
R5301 53 1 1.154936610715911
R5302 53 2 1.0669219050157914
R5303 53 3 0.9392721626314599
R5304 53 4 1.1722526422111197
R5305 53 5 1.7771469671965
R5306 53 6 0.9482470202419009
R5307 53 7 0.6350351226554543
R5308 53 8 1.2671059777261986
R5309 53 9 0.7839672354797775
R5310 53 10 1.1006161881824514
R5311 53 11 0.4503355109652061
R5312 53 12 0.8061913392987934
R5313 53 13 1.1570415748467568
R5314 53 14 1.8512783012600469
R5315 53 15 0.5261209732577886
R5316 53 16 1.0615835865939662
R5317 53 17 0.3698758063628216
R5318 53 18 0.8762503294553411
R5319 53 19 0.7421412735596274
R5320 53 20 1.1671958452502715
R5321 53 21 1.1504464041294602
R5322 53 22 1.660604678965587
R5323 53 23 1.230089803057104
R5324 53 24 1.538300501367274
R5325 53 25 0.603879193396204
R5326 53 26 0.6845715113353243
R5327 53 27 1.5881694517225755
R5328 53 28 0.5778977921677658
R5329 53 29 1.5268875048757817
R5330 53 30 1.3805037180581476
R5331 53 31 0.4957239780654564
R5332 53 32 0.7924674736580395
R5333 53 33 0.8305869194456672
R5334 53 34 0.5133222222672703
R5335 53 35 0.5043511096880444
R5336 53 36 0.6887511991293227
R5337 53 37 0.781092206345437
R5338 53 38 0.2169481924628207
R5339 53 39 1.3575425237154044
R5340 53 40 1.2982229700858126
R5341 53 41 0.18885494163013494
R5342 53 42 0.8139740783530731
R5343 53 43 1.2913945452904216
R5344 53 44 1.464931242605212
R5345 53 45 1.0283833851048714
R5346 53 46 1.4417370279763007
R5347 53 47 0.8287304008030933
R5348 53 48 0.6031117579550522
R5349 53 49 1.0347840668112531
R5350 53 50 0.5730874152939058
R5351 53 51 0.6326207554842486
R5352 53 52 1.4443430845927299
R5400 54 0 1.0862220749337521
R5401 54 1 1.1959735122016035
R5402 54 2 1.4153222519487212
R5403 54 3 0.9442028810590525
R5404 54 4 1.502396925208929
R5405 54 5 0.324086241477492
R5406 54 6 0.8603665070744736
R5407 54 7 0.9009521769245078
R5408 54 8 1.4988895452327569
R5409 54 9 1.4371999298494518
R5410 54 10 1.820256989626921
R5411 54 11 1.0575987922154244
R5412 54 12 1.7846662380065972
R5413 54 13 0.6300090359899039
R5414 54 14 0.9937681264048916
R5415 54 15 0.6511879215918734
R5416 54 16 0.40917311094454134
R5417 54 17 0.6471577364652227
R5418 54 18 1.6111621223484383
R5419 54 19 1.4633084731186419
R5420 54 20 0.9036555585745805
R5421 54 21 0.20239412921785216
R5422 54 22 0.8251621768064322
R5423 54 23 0.9242591846845251
R5424 54 24 1.0560171444960624
R5425 54 25 0.34407132758532466
R5426 54 26 0.9780755288869962
R5427 54 27 1.1909458263087034
R5428 54 28 1.3771190994627442
R5429 54 29 1.551955566855633
R5430 54 30 0.47646077529969866
R5431 54 31 1.3667886056303584
R5432 54 32 1.1596382098481661
R5433 54 33 0.48987065036097077
R5434 54 34 1.2661287969947628
R5435 54 35 1.069433824258127
R5436 54 36 1.8409624558123723
R5437 54 37 1.8521382227832113
R5438 54 38 1.474116443773514
R5439 54 39 0.9986228761938382
R5440 54 40 1.2475735533482744
R5441 54 41 1.010536744771731
R5442 54 42 1.2363897336756993
R5443 54 43 1.3673006036708553
R5444 54 44 1.3521198600915114
R5445 54 45 1.3230275873516504
R5446 54 46 0.38151824032231696
R5447 54 47 1.2392244817201088
R5448 54 48 1.3918665546491955
R5449 54 49 0.9484573690538375
R5450 54 50 0.6644800240370475
R5451 54 51 0.7228191329826457
R5452 54 52 1.1045962889465852
R5453 54 53 0.20765203933809462
R5500 55 0 1.3319723630153772
R5501 55 1 1.1357951576338428
R5502 55 2 1.093381004912573
R5503 55 3 0.4816330896223261
R5504 55 4 0.6812224717280833
R5505 55 5 0.15921063758662124
R5506 55 6 0.8318094874071825
R5507 55 7 0.4009898788013613
R5508 55 8 1.1383104031138032
R5509 55 9 0.7126143750686122
R5510 55 10 1.6815400445790174
R5511 55 11 0.7445258887019571
R5512 55 12 0.4304683551762486
R5513 55 13 0.7897947260281987
R5514 55 14 1.718922715881066
R5515 55 15 0.6022237871666184
R5516 55 16 0.6422275987358698
R5517 55 17 0.975310754104543
R5518 55 18 1.1586934697396312
R5519 55 19 0.5187054433537089
R5520 55 20 0.7395445004583647
R5521 55 21 1.7351319774213092
R5522 55 22 0.16099625328088896
R5523 55 23 0.9246455172171816
R5524 55 24 0.7853989825872592
R5525 55 25 0.3302635530115665
R5526 55 26 0.46620185830842176
R5527 55 27 0.9330435471332482
R5528 55 28 1.146176368312402
R5529 55 29 1.105118977053356
R5530 55 30 0.7312094507195106
R5531 55 31 1.6336659524199764
R5532 55 32 1.7857489876656159
R5533 55 33 1.1065749195607069
R5534 55 34 0.6854704438734989
R5535 55 35 0.8714213963139348
R5536 55 36 1.0896207367211543
R5537 55 37 1.0591805370733773
R5538 55 38 1.2342028974959791
R5539 55 39 1.778424907189054
R5540 55 40 1.1891903564352662
R5541 55 41 1.0614466344227114
R5542 55 42 0.773156140010122
R5543 55 43 0.7791456711583924
R5544 55 44 1.165605401316984
R5545 55 45 0.24091504269165798
R5546 55 46 1.333886534652977
R5547 55 47 0.48545643838144126
R5548 55 48 1.585041110408757
R5549 55 49 1.5676755459412735
R5550 55 50 1.0780188134118438
R5551 55 51 1.3066651753461969
R5552 55 52 1.1596306911509238
R5553 55 53 1.589137577342493
R5554 55 54 0.8433678203143866
R5600 56 0 1.0300504824527121
R5601 56 1 1.2067613025601052
R5602 56 2 0.27378175701251084
R5603 56 3 0.7392258619690403
R5604 56 4 1.6241358944175361
R5605 56 5 0.9217816399926565
R5606 56 6 0.635645391697479
R5607 56 7 1.7179099926456174
R5608 56 8 1.1626041689740498
R5609 56 9 1.097338499156787
R5610 56 10 0.5667769440016087
R5611 56 11 1.0350365356439486
R5612 56 12 0.45915390856705895
R5613 56 13 1.4722669270169533
R5614 56 14 0.3486368699860949
R5615 56 15 1.1345883276371835
R5616 56 16 0.9337299234709701
R5617 56 17 0.40691122831055315
R5618 56 18 0.864545679743579
R5619 56 19 1.185553431594219
R5620 56 20 0.6762094928248189
R5621 56 21 0.8599736010601501
R5622 56 22 0.4590709504516701
R5623 56 23 0.9631992409122172
R5624 56 24 1.585083788134563
R5625 56 25 0.6833437172282886
R5626 56 26 0.9151074934257913
R5627 56 27 0.9114812962643407
R5628 56 28 1.2488181346493212
R5629 56 29 0.5855314366853321
R5630 56 30 0.8698615694524865
R5631 56 31 1.668886899917571
R5632 56 32 0.349016886758994
R5633 56 33 0.4559372350557115
R5634 56 34 0.6310852784673707
R5635 56 35 0.29995383987533475
R5636 56 36 0.8579710847868077
R5637 56 37 0.8280655058372155
R5638 56 38 1.2171148499261701
R5639 56 39 1.8898273789712172
R5640 56 40 0.7030123679722237
R5641 56 41 1.2958601566908126
R5642 56 42 0.6436443518322372
R5643 56 43 0.7824817973008994
R5644 56 44 1.5385024423632427
R5645 56 45 0.7216228494910691
R5646 56 46 1.5451013566532108
R5647 56 47 1.2761891090389723
R5648 56 48 0.3967704453423361
R5649 56 49 0.631797196045243
R5650 56 50 1.082750819918294
R5651 56 51 1.100381076538194
R5652 56 52 0.19420559239417934
R5653 56 53 0.6493635962188151
R5654 56 54 0.3727168552698471
R5655 56 55 0.8283824964189156
R5700 57 0 0.7890157693405879
R5701 57 1 0.3348802132777392
R5702 57 2 0.9878493952506113
R5703 57 3 0.9532749549598561
R5704 57 4 0.24711011145362372
R5705 57 5 1.0402416091259588
R5706 57 6 1.669133493958082
R5707 57 7 1.5154091405220327
R5708 57 8 1.741408531214109
R5709 57 9 1.0683699165458316
R5710 57 10 0.6515458550885707
R5711 57 11 0.9996829963893903
R5712 57 12 0.7665617780707623
R5713 57 13 1.1778081552646233
R5714 57 14 0.7528224657460821
R5715 57 15 0.21450419234012297
R5716 57 16 0.9856605613716495
R5717 57 17 0.9512214542889824
R5718 57 18 1.0076941102817207
R5719 57 19 1.2957050957603506
R5720 57 20 0.39258065213957993
R5721 57 21 1.4755530186869337
R5722 57 22 0.8748834038960347
R5723 57 23 1.800441645680983
R5724 57 24 0.9613249793821099
R5725 57 25 1.1653558490555995
R5726 57 26 1.4001571840615363
R5727 57 27 0.730595831646859
R5728 57 28 1.0233877344908289
R5729 57 29 0.9905379122540029
R5730 57 30 1.414355866326626
R5731 57 31 0.9548659615398358
R5732 57 32 0.6004349778720499
R5733 57 33 1.1495020169623849
R5734 57 34 0.8915601986230668
R5735 57 35 1.5398719182228637
R5736 57 36 0.5688377107612027
R5737 57 37 1.0140394897589373
R5738 57 38 1.1570899080667258
R5739 57 39 0.8830571160758065
R5740 57 40 1.086574615037094
R5741 57 41 0.7591790530013574
R5742 57 42 1.7599459749888515
R5743 57 43 1.440119209856376
R5744 57 44 1.3435986740291512
R5745 57 45 0.7157281578974678
R5746 57 46 1.4697126471595126
R5747 57 47 1.5251132139520953
R5748 57 48 1.0727669458192874
R5749 57 49 0.7110534536442146
R5750 57 50 1.575959356921105
R5751 57 51 1.0998329210143298
R5752 57 52 0.5465773646838124
R5753 57 53 0.5740515606914809
R5754 57 54 1.9270940971715302
R5755 57 55 1.0592230539265606
R5756 57 56 0.13545910043221032
R5800 58 0 1.0055975996438664
R5801 58 1 1.0382904656603502
R5802 58 2 1.14204903877978
R5803 58 3 0.7440064587485288
R5804 58 4 1.0691614458306375
R5805 58 5 1.118162296621365
R5806 58 6 0.40475111414351206
R5807 58 7 1.7704996491292118
R5808 58 8 0.7919256407012168
R5809 58 9 1.458229057202967
R5810 58 10 1.9787319286451384
R5811 58 11 0.323633604452192
R5812 58 12 0.4263641115409742
R5813 58 13 1.0963469266461763
R5814 58 14 0.8338117585034444
R5815 58 15 0.129623612546644
R5816 58 16 1.2640024630737312
R5817 58 17 0.44603489206032465
R5818 58 18 1.5609872127044577
R5819 58 19 0.7902421412664974
R5820 58 20 1.8458631643256886
R5821 58 21 1.3952453734554209
R5822 58 22 0.2060597024140397
R5823 58 23 0.3087249996931214
R5824 58 24 0.7633674392164667
R5825 58 25 0.94228414363305
R5826 58 26 0.34379904086215185
R5827 58 27 0.9853291772546415
R5828 58 28 1.3913502190647824
R5829 58 29 1.016509340546523
R5830 58 30 0.5933085796283272
R5831 58 31 1.0285634768801397
R5832 58 32 1.223828516912942
R5833 58 33 0.5892865496746481
R5834 58 34 0.84538334438301
R5835 58 35 0.8343337989980792
R5836 58 36 0.6351864688858256
R5837 58 37 0.31667956295728705
R5838 58 38 1.058694144408988
R5839 58 39 0.8811074400847817
R5840 58 40 1.2919656174824379
R5841 58 41 0.7298571360988977
R5842 58 42 0.9612192991339287
R5843 58 43 1.8340494930767712
R5844 58 44 0.5463872801575701
R5845 58 45 0.45341759567820894
R5846 58 46 1.603072218988068
R5847 58 47 1.3807844978006838
R5848 58 48 0.9036515596180245
R5849 58 49 0.9781570090656906
R5850 58 50 1.1114828513690482
R5851 58 51 1.3397964626290655
R5852 58 52 0.8971898535151952
R5853 58 53 1.242619384131259
R5854 58 54 1.4781212114039497
R5855 58 55 0.77118515612048
R5856 58 56 0.5158650363889022
R5857 58 57 0.9171440520311612
R5900 59 0 1.118119085512614
R5901 59 1 1.2153663807227146
R5902 59 2 0.5728522751792954
R5903 59 3 1.1268136474601573
R5904 59 4 0.707813293513713
R5905 59 5 1.735119724054468
R5906 59 6 0.9933664878787766
R5907 59 7 0.9090822530286626
R5908 59 8 1.4005045972736787
R5909 59 9 0.4456931674916562
R5910 59 10 0.9776391008355729
R5911 59 11 1.150056266653888
R5912 59 12 1.0425838698843897
R5913 59 13 0.8688414291450864
R5914 59 14 1.1463657716565199
R5915 59 15 1.074891343854445
R5916 59 16 1.0786446466964923
R5917 59 17 0.37797652665038306
R5918 59 18 0.8668543697649025
R5919 59 19 0.5052021756801932
R5920 59 20 1.0046596879198075
R5921 59 21 0.6771367548505397
R5922 59 22 1.3485217327161483
R5923 59 23 0.3402252743327029
R5924 59 24 1.342461687916408
R5925 59 25 1.5061656321573276
R5926 59 26 0.9563621860712554
R5927 59 27 0.7673671816071426
R5928 59 28 1.3245911443204386
R5929 59 29 0.4868857073917644
R5930 59 30 1.0417572568645053
R5931 59 31 1.1639449902384194
R5932 59 32 1.5052029379243295
R5933 59 33 1.474922578804537
R5934 59 34 1.113858062217332
R5935 59 35 0.751646591877799
R5936 59 36 0.6773478770247388
R5937 59 37 1.2264554888325665
R5938 59 38 0.32820870252682277
R5939 59 39 1.1794034560477933
R5940 59 40 0.49629204766372126
R5941 59 41 1.3318942695378584
R5942 59 42 1.4501806808856887
R5943 59 43 1.1239880750649496
R5944 59 44 1.912568609155484
R5945 59 45 0.8195385399480284
R5946 59 46 0.8605517086758483
R5947 59 47 0.7900761283090344
R5948 59 48 1.5751253329027568
R5949 59 49 1.1445701837897047
R5950 59 50 0.2172731709806186
R5951 59 51 1.210409732384178
R5952 59 52 1.0200259492257189
R5953 59 53 1.1318257606458346
R5954 59 54 1.061699576565848
R5955 59 55 1.0576566460501335
R5956 59 56 0.5992505567081557
R5957 59 57 1.4113688862451776
R5958 59 58 1.2224250730596422
R6000 60 0 1.1609680415324577
R6001 60 1 1.0937612608718865
R6002 60 2 1.688734735714935
R6003 60 3 1.5539948655773594
R6004 60 4 1.4512628905664835
R6005 60 5 1.3458584662288429
R6006 60 6 0.9021700339792197
R6007 60 7 0.795462570193903
R6008 60 8 0.7781558003920737
R6009 60 9 0.9851965837093032
R6010 60 10 0.948627879813979
R6011 60 11 1.2495796135853245
R6012 60 12 1.7982538399005854
R6013 60 13 1.075284010546812
R6014 60 14 0.9994982774608718
R6015 60 15 1.595561222607285
R6016 60 16 1.3397633952393906
R6017 60 17 0.37130691327643717
R6018 60 18 1.3683297591009396
R6019 60 19 1.0549199002311829
R6020 60 20 0.7954907964740405
R6021 60 21 0.9670598515961946
R6022 60 22 0.8214547432727967
R6023 60 23 1.4895988230658719
R6024 60 24 0.6373251662401376
R6025 60 25 1.178904664416746
R6026 60 26 0.7751542838625498
R6027 60 27 1.6591532490852312
R6028 60 28 1.5105311319126584
R6029 60 29 0.646131834574666
R6030 60 30 1.3058143304555605
R6031 60 31 1.1759490752039738
R6032 60 32 1.396116929683422
R6033 60 33 0.6233666726114856
R6034 60 34 0.3015755063669193
R6035 60 35 1.354420188685934
R6036 60 36 1.004118903612611
R6037 60 37 0.8144145013315639
R6038 60 38 1.2043722705031803
R6039 60 39 0.6911129350706674
R6040 60 40 0.49739661849683814
R6041 60 41 1.3595052344920378
R6042 60 42 1.3650561379176116
R6043 60 43 1.0491760409543183
R6044 60 44 0.7092620396000304
R6045 60 45 1.2017831568995978
R6046 60 46 1.4408305572012792
R6047 60 47 0.5271010023473316
R6048 60 48 0.7639817658466703
R6049 60 49 0.46951840120030774
R6050 60 50 0.8204705085402454
R6051 60 51 0.6810667090256262
R6052 60 52 1.3529589854152775
R6053 60 53 1.5226201609412784
R6054 60 54 0.9575798641796806
R6055 60 55 0.5312991784222485
R6056 60 56 0.7061890362533032
R6057 60 57 0.13595681085683886
R6058 60 58 1.293464911963323
R6059 60 59 0.4217488268634917
R6100 61 0 1.7938537968675963
R6101 61 1 0.9084788404178311
R6102 61 2 0.9608773296490624
R6103 61 3 1.0026547410752538
R6104 61 4 0.9559569173156336
R6105 61 5 1.5115073577291684
R6106 61 6 0.8707234926834183
R6107 61 7 1.1357638363312934
R6108 61 8 0.8786377013465346
R6109 61 9 0.90353484358311
R6110 61 10 1.3981031027824993
R6111 61 11 0.8105031503538129
R6112 61 12 0.9530184757545442
R6113 61 13 0.2448864701334359
R6114 61 14 1.2126788890430182
R6115 61 15 1.2864138438578938
R6116 61 16 1.0034039372314685
R6117 61 17 0.6857681595979437
R6118 61 18 0.4684454685517999
R6119 61 19 0.9854339054226035
R6120 61 20 0.8537446411689574
R6121 61 21 1.633250337615486
R6122 61 22 1.8527951884635314
R6123 61 23 1.0326626025159404
R6124 61 24 1.2517381975876782
R6125 61 25 1.3355865819217985
R6126 61 26 0.28827823934053
R6127 61 27 1.0617873797623345
R6128 61 28 0.8485497195519454
R6129 61 29 0.6195007810156381
R6130 61 30 1.0146065521408776
R6131 61 31 0.9712022178308504
R6132 61 32 0.520132528545811
R6133 61 33 1.822840379453227
R6134 61 34 1.0241285414012193
R6135 61 35 0.8969051603397535
R6136 61 36 0.9502488435985137
R6137 61 37 0.28203941239970254
R6138 61 38 0.8306167526964561
R6139 61 39 1.6879420139456656
R6140 61 40 1.0446678514034025
R6141 61 41 0.7769053523830367
R6142 61 42 0.1316655038412886
R6143 61 43 1.0925596964654662
R6144 61 44 0.8830342104558663
R6145 61 45 1.3508886768303054
R6146 61 46 1.610428966253307
R6147 61 47 1.431031939716306
R6148 61 48 0.6788425245757075
R6149 61 49 0.5697604167692187
R6150 61 50 1.192726811941851
R6151 61 51 0.9681840287390593
R6152 61 52 1.0834391310455316
R6153 61 53 0.6604203116696717
R6154 61 54 0.9656090693113026
R6155 61 55 0.7738416419668049
R6156 61 56 1.02795985214898
R6157 61 57 1.2535118968277208
R6158 61 58 0.7505899160600691
R6159 61 59 1.1083479043744697
R6160 61 60 0.7256242561221705
R6200 62 0 0.918655780056742
R6201 62 1 1.2130816869658
R6202 62 2 0.9602995716204541
R6203 62 3 0.9711026878863587
R6204 62 4 1.3064301423045643
R6205 62 5 1.6694192883222958
R6206 62 6 1.5284148524014873
R6207 62 7 0.7988135600502287
R6208 62 8 1.0066998817279758
R6209 62 9 1.1781547661242058
R6210 62 10 0.9572505529608104
R6211 62 11 1.0081452775667845
R6212 62 12 1.0850387409823727
R6213 62 13 1.2750809226909525
R6214 62 14 1.3645471668495848
R6215 62 15 0.3995595533889723
R6216 62 16 0.2977752956657215
R6217 62 17 1.4802049488174744
R6218 62 18 1.1458217321094057
R6219 62 19 1.7750035908433452
R6220 62 20 1.3745121011325467
R6221 62 21 1.0377371449325115
R6222 62 22 0.524519809288795
R6223 62 23 0.5031887841229764
R6224 62 24 1.9475875378919318
R6225 62 25 0.2775192457621012
R6226 62 26 0.5791433297858698
R6227 62 27 0.6820705461261477
R6228 62 28 0.8134547996402509
R6229 62 29 0.2744745876230337
R6230 62 30 1.150993345970235
R6231 62 31 1.7545644158466507
R6232 62 32 1.3225741464532481
R6233 62 33 0.8589093960510297
R6234 62 34 0.48357129494545137
R6235 62 35 1.1497757505195811
R6236 62 36 1.0442721443424476
R6237 62 37 1.6596170481634502
R6238 62 38 0.7678127964470468
R6239 62 39 0.670062852636774
R6240 62 40 0.9432201076368719
R6241 62 41 0.5450759266721501
R6242 62 42 0.5972463616539655
R6243 62 43 0.7389311871103991
R6244 62 44 1.62339549666485
R6245 62 45 0.775686680219154
R6246 62 46 1.0694827820951995
R6247 62 47 0.6250897181346847
R6248 62 48 1.2084126771092358
R6249 62 49 0.9914838271054366
R6250 62 50 1.3153865310000086
R6251 62 51 0.5581944645193219
R6252 62 52 1.0873808579445425
R6253 62 53 1.3159361352727745
R6254 62 54 0.6996205299083124
R6255 62 55 1.3121016539987465
R6256 62 56 1.1117095639032089
R6257 62 57 0.4837656588448225
R6258 62 58 1.4382567513862812
R6259 62 59 0.850949641022968
R6260 62 60 0.8122749308774421
R6261 62 61 1.4913370924783704
R6300 63 0 0.9108745098173625
R6301 63 1 0.45683342755727496
R6302 63 2 1.1912799811675194
R6303 63 3 0.7123345548621073
R6304 63 4 0.5116996383094335
R6305 63 5 0.7566460196678414
R6306 63 6 0.5662142459660694
R6307 63 7 1.0277552422287979
R6308 63 8 1.561863384889953
R6309 63 9 0.7588965605812235
R6310 63 10 1.1538794656857259
R6311 63 11 0.3678399706980866
R6312 63 12 1.4650386497775416
R6313 63 13 1.4909224675288444
R6314 63 14 1.2666594532466189
R6315 63 15 1.4458717607640912
R6316 63 16 0.9130911940980508
R6317 63 17 1.116866805724407
R6318 63 18 1.0392208475402114
R6319 63 19 1.2566500572735257
R6320 63 20 1.716030796819891
R6321 63 21 0.7319001891632377
R6322 63 22 0.6888764078355429
R6323 63 23 1.916900933498849
R6324 63 24 0.9996694619502812
R6325 63 25 1.2042877759141
R6326 63 26 1.0907516946488678
R6327 63 27 0.41594004678639307
R6328 63 28 0.992773969410591
R6329 63 29 0.8070573718094467
R6330 63 30 0.42075031638143556
R6331 63 31 1.1357649234158294
R6332 63 32 0.5625813204572502
R6333 63 33 1.496151478030785
R6334 63 34 1.7418323938599958
R6335 63 35 1.3102192860339184
R6336 63 36 0.9416328776710831
R6337 63 37 0.2868461705767821
R6338 63 38 1.1668757282750402
R6339 63 39 1.2480567130193392
R6340 63 40 0.4649098050353263
R6341 63 41 0.19077583329869696
R6342 63 42 1.8249393535401897
R6343 63 43 1.7124992143919684
R6344 63 44 1.1658164184361883
R6345 63 45 1.8868934120247074
R6346 63 46 0.7412535987504131
R6347 63 47 1.6781762202584125
R6348 63 48 0.2010748757901144
R6349 63 49 0.7951665991559788
R6350 63 50 1.1643738286348424
R6351 63 51 1.111037950980145
R6352 63 52 0.9966142169097307
R6353 63 53 1.1296378856667446
R6354 63 54 0.35312867035537365
R6355 63 55 1.3241758882206371
R6356 63 56 1.7390747975666325
R6357 63 57 1.3151462999623424
R6358 63 58 1.0689677273524212
R6359 63 59 0.7870035492363271
R6360 63 60 0.7861703392483766
R6361 63 61 1.2627337646455725
R6362 63 62 0.19446707389492923
R6400 64 0 1.2508653569025365
R6401 64 1 1.5910802046305337
R6402 64 2 0.6715253917345719
R6403 64 3 0.6632671128488131
R6404 64 4 1.337820352080913
R6405 64 5 1.713444651553788
R6406 64 6 0.7492101333317619
R6407 64 7 1.1549850149605665
R6408 64 8 1.563075588846199
R6409 64 9 0.6127775758695622
R6410 64 10 1.1941211056749648
R6411 64 11 0.7799236257854951
R6412 64 12 0.8367065951450983
R6413 64 13 1.042164874773155
R6414 64 14 1.1367671911355193
R6415 64 15 1.021872154757722
R6416 64 16 1.295264942339589
R6417 64 17 0.9161157575897939
R6418 64 18 0.6714474981854622
R6419 64 19 0.5228947342924454
R6420 64 20 1.1902491956676973
R6421 64 21 1.0499747457262383
R6422 64 22 0.9257699274661302
R6423 64 23 0.8032025232875677
R6424 64 24 1.1018581490451953
R6425 64 25 1.1442280595596752
R6426 64 26 1.2728415893517573
R6427 64 27 1.701382989844022
R6428 64 28 1.2669909422471135
R6429 64 29 0.7733983713035417
R6430 64 30 0.831719513739639
R6431 64 31 0.5516786111304547
R6432 64 32 1.169283522268617
R6433 64 33 0.44648287230532946
R6434 64 34 0.43619118093142295
R6435 64 35 0.673005213955335
R6436 64 36 1.8376489741607493
R6437 64 37 1.3391610550740953
R6438 64 38 1.7746154979427757
R6439 64 39 0.8877283676224238
R6440 64 40 0.11538375698970005
R6441 64 41 0.453565702971206
R6442 64 42 0.5077831667324382
R6443 64 43 1.2052421619990532
R6444 64 44 1.2865759646496349
R6445 64 45 0.9046376468693706
R6446 64 46 0.8930776143827616
R6447 64 47 0.8978580907313992
R6448 64 48 0.85550978988871
R6449 64 49 0.8416451257463988
R6450 64 50 1.3215640213709614
R6451 64 51 1.095006662166615
R6452 64 52 1.416388570059774
R6453 64 53 0.6895246991566628
R6454 64 54 0.42154933717509624
R6455 64 55 0.9506152915011786
R6456 64 56 0.4805100442538389
R6457 64 57 0.8280079142089809
R6458 64 58 0.6761077143291007
R6459 64 59 0.4308760255089361
R6460 64 60 1.1117806751793309
R6461 64 61 0.9671896028697907
R6462 64 62 0.23630349062292366
R6463 64 63 0.35327821341693355
R6500 65 0 1.499236134386183
R6501 65 1 0.8227942778583096
R6502 65 2 1.4674340844180624
R6503 65 3 0.9742711493680389
R6504 65 4 0.9335150811939941
R6505 65 5 1.3481517571120796
R6506 65 6 0.8568689382734287
R6507 65 7 1.2288905920770414
R6508 65 8 1.2133598239149
R6509 65 9 1.2095650818642443
R6510 65 10 1.9121611098028453
R6511 65 11 0.29052150098571805
R6512 65 12 1.0658675046698476
R6513 65 13 1.2824043285742026
R6514 65 14 1.097716604289253
R6515 65 15 1.5023700938467635
R6516 65 16 1.098700658448086
R6517 65 17 1.1884524569131814
R6518 65 18 0.4987377817363564
R6519 65 19 1.3941271548159704
R6520 65 20 0.7145530775034863
R6521 65 21 0.8849835464320361
R6522 65 22 1.4342980652473245
R6523 65 23 1.3979535974949218
R6524 65 24 1.5067352798864913
R6525 65 25 1.1977003517621472
R6526 65 26 0.37522523920570894
R6527 65 27 0.6587899398265603
R6528 65 28 1.2446620672087039
R6529 65 29 1.3527921296047554
R6530 65 30 0.9975011117441415
R6531 65 31 0.8668032314464844
R6532 65 32 0.5650139707853699
R6533 65 33 1.1670728544682287
R6534 65 34 1.8718550633726396
R6535 65 35 0.7465477541679303
R6536 65 36 0.8063362401609008
R6537 65 37 1.3410364046392083
R6538 65 38 1.2976705174860026
R6539 65 39 0.8130290969426714
R6540 65 40 1.759984398253911
R6541 65 41 1.7308601569816018
R6542 65 42 0.905402920310144
R6543 65 43 0.6491556590041989
R6544 65 44 0.8924424079007919
R6545 65 45 1.6413051154972416
R6546 65 46 1.7598449434047132
R6547 65 47 0.3750638316221845
R6548 65 48 0.64339216829673
R6549 65 49 0.7497121566666858
R6550 65 50 1.0823936862120946
R6551 65 51 1.000170389407341
R6552 65 52 0.291738309458193
R6553 65 53 0.7099253826783145
R6554 65 54 1.4011802880251976
R6555 65 55 0.6802305670617979
R6556 65 56 0.9342608656331486
R6557 65 57 1.5034130068464315
R6558 65 58 0.14780202907145867
R6559 65 59 1.628684283909013
R6560 65 60 0.7534274956266181
R6561 65 61 1.2518907154771912
R6562 65 62 1.033812328759242
R6563 65 63 1.2576226052955155
R6564 65 64 1.0245387761900835
R6600 66 0 0.37445041886785524
R6601 66 1 0.9929562574431552
R6602 66 2 0.26311039962997784
R6603 66 3 1.651670202707584
R6604 66 4 0.9139167845243341
R6605 66 5 0.7146823089187344
R6606 66 6 1.002509202472483
R6607 66 7 0.5534011715027928
R6608 66 8 1.1069643121017565
R6609 66 9 1.8089651692487094
R6610 66 10 1.2738465154756007
R6611 66 11 1.1034405284789763
R6612 66 12 0.7365500566662102
R6613 66 13 0.2184740684986729
R6614 66 14 0.7606507300016764
R6615 66 15 1.6625298826363668
R6616 66 16 1.236213731294729
R6617 66 17 0.8902060027683678
R6618 66 18 1.6965124896517412
R6619 66 19 1.204383565595102
R6620 66 20 1.1242893137117986
R6621 66 21 1.0462851425834783
R6622 66 22 0.5480318345071461
R6623 66 23 1.3380173641040412
R6624 66 24 1.0150975573915106
R6625 66 25 0.8759690900575257
R6626 66 26 0.936632921684475
R6627 66 27 1.5260508912734205
R6628 66 28 0.7357084752033245
R6629 66 29 1.0357120957403796
R6630 66 30 0.4870283935006716
R6631 66 31 0.5249560555199156
R6632 66 32 1.1442363427393907
R6633 66 33 1.1947437196226292
R6634 66 34 1.0926384874148662
R6635 66 35 1.7264076014968412
R6636 66 36 0.961767981264443
R6637 66 37 1.3819606509010214
R6638 66 38 0.9709082503951377
R6639 66 39 0.645004921981572
R6640 66 40 0.9413517384875411
R6641 66 41 1.4586708800342292
R6642 66 42 1.1148593440605974
R6643 66 43 1.2015387126460442
R6644 66 44 0.2726120984272007
R6645 66 45 1.1176477644936857
R6646 66 46 0.7176649123825065
R6647 66 47 0.8972866433384005
R6648 66 48 1.2717148550792707
R6649 66 49 0.7865291913043583
R6650 66 50 0.9850872794145767
R6651 66 51 1.0670351296512801
R6652 66 52 0.8464439548925421
R6653 66 53 0.7267473394755377
R6654 66 54 1.5514520719279812
R6655 66 55 1.0786936000674396
R6656 66 56 0.8523003272919827
R6657 66 57 0.7136983204230704
R6658 66 58 1.5672589563085357
R6659 66 59 1.682431476037404
R6660 66 60 1.14375213320573
R6661 66 61 0.8444212962551512
R6662 66 62 1.677634261118474
R6663 66 63 0.7116417237464208
R6664 66 64 0.40663437287751913
R6665 66 65 0.34736896370253667
R6700 67 0 0.15612976894497377
R6701 67 1 1.7695929569868971
R6702 67 2 0.7931505766533821
R6703 67 3 0.9644823027171548
R6704 67 4 1.3459684529111038
R6705 67 5 1.0604493030083577
R6706 67 6 0.7385902226590277
R6707 67 7 1.4448046204386737
R6708 67 8 0.569081461223959
R6709 67 9 1.612347124335745
R6710 67 10 0.968411429716208
R6711 67 11 1.0328816437854955
R6712 67 12 0.8902296533632195
R6713 67 13 0.36934089992148855
R6714 67 14 1.3026107097302293
R6715 67 15 0.4679742649740867
R6716 67 16 1.3315801348240892
R6717 67 17 1.4080783878060645
R6718 67 18 1.7396406865468372
R6719 67 19 0.47596401949865585
R6720 67 20 1.2320500924906126
R6721 67 21 1.0976449110838264
R6722 67 22 0.6835933436455062
R6723 67 23 0.6733093402725521
R6724 67 24 0.7379466600596184
R6725 67 25 0.6897393876856074
R6726 67 26 1.072597291505692
R6727 67 27 0.7022448221042829
R6728 67 28 0.8865114290928878
R6729 67 29 0.9547205969112065
R6730 67 30 0.7924726693992763
R6731 67 31 0.7447001721224633
R6732 67 32 1.643649264844976
R6733 67 33 1.2634504227586463
R6734 67 34 1.3104562777171596
R6735 67 35 1.5913588986214784
R6736 67 36 0.9895407210885574
R6737 67 37 1.3073429716957166
R6738 67 38 0.5312666386687943
R6739 67 39 0.6611707695336584
R6740 67 40 1.0374991232431299
R6741 67 41 0.5349277858079181
R6742 67 42 0.4126804409220717
R6743 67 43 0.34071913371233886
R6744 67 44 1.3168556797401587
R6745 67 45 0.9528500081085131
R6746 67 46 1.5517323288166986
R6747 67 47 1.1572156157032112
R6748 67 48 1.3756898789746201
R6749 67 49 1.0473248809304145
R6750 67 50 1.747961475967766
R6751 67 51 0.5915237797387755
R6752 67 52 0.8920855057705108
R6753 67 53 1.0460760440739076
R6754 67 54 1.4823974618462512
R6755 67 55 1.7790799137344893
R6756 67 56 0.8907948468040948
R6757 67 57 1.554131277846385
R6758 67 58 1.7315651845911781
R6759 67 59 1.2909656968566714
R6760 67 60 1.022204567448437
R6761 67 61 1.1400328801773663
R6762 67 62 0.3653897232168579
R6763 67 63 0.777040227841338
R6764 67 64 0.7898885055754643
R6765 67 65 1.003865103162643
R6766 67 66 1.5988954580732129
R6800 68 0 1.4385595208992654
R6801 68 1 1.1340410255300752
R6802 68 2 1.0990746571750099
R6803 68 3 0.2951896948389501
R6804 68 4 0.29214631718123607
R6805 68 5 0.8685468932340878
R6806 68 6 0.900451555283878
R6807 68 7 1.2628211983173636
R6808 68 8 0.608795019283485
R6809 68 9 0.3036344142200381
R6810 68 10 0.6418907437396146
R6811 68 11 0.3262578379527422
R6812 68 12 0.7346368294394395
R6813 68 13 1.2449102621213517
R6814 68 14 1.1085155595685343
R6815 68 15 0.3286510762563176
R6816 68 16 0.5427386220184247
R6817 68 17 1.1453450132953584
R6818 68 18 1.2561956678303146
R6819 68 19 1.7821119521038606
R6820 68 20 0.7281999635331811
R6821 68 21 1.4572654627202868
R6822 68 22 0.7047301432578627
R6823 68 23 1.0874189676647443
R6824 68 24 1.0160951498898405
R6825 68 25 1.4379280486066892
R6826 68 26 0.7588719175243662
R6827 68 27 0.6046344712635193
R6828 68 28 1.0977788045255426
R6829 68 29 1.6315823223053492
R6830 68 30 1.0043627791615786
R6831 68 31 0.8506280686173152
R6832 68 32 0.8309895254654671
R6833 68 33 0.1673058259536775
R6834 68 34 1.1876455625262126
R6835 68 35 0.1840311636721229
R6836 68 36 0.9223058946386211
R6837 68 37 0.6938928562289958
R6838 68 38 1.715909387977177
R6839 68 39 1.0122807825184315
R6840 68 40 1.1580194424412047
R6841 68 41 1.2300075865937043
R6842 68 42 1.4497688536999018
R6843 68 43 0.5316930328329065
R6844 68 44 1.1420008008168612
R6845 68 45 0.8263129924953941
R6846 68 46 1.094905259632806
R6847 68 47 0.26923644934083113
R6848 68 48 1.0165720132656673
R6849 68 49 1.4925235586791679
R6850 68 50 1.2092799378998111
R6851 68 51 1.3107953698764214
R6852 68 52 0.6317019463913636
R6853 68 53 0.8429084466515354
R6854 68 54 1.5217980429375921
R6855 68 55 0.7210223290658121
R6856 68 56 0.5871257978372433
R6857 68 57 1.6273462033201411
R6858 68 58 0.9287493209252516
R6859 68 59 0.7696076305078828
R6860 68 60 1.4850370050363277
R6861 68 61 1.4385529481847095
R6862 68 62 0.34381428764793187
R6863 68 63 0.8571000048536735
R6864 68 64 1.4408719426737064
R6865 68 65 1.190974140650227
R6866 68 66 1.1926308789337492
R6867 68 67 1.3751232961422102
R6900 69 0 0.5812139526104302
R6901 69 1 1.8519789409062124
R6902 69 2 0.4275675714642212
R6903 69 3 0.3413942396122267
R6904 69 4 0.9445698755361552
R6905 69 5 1.4202419205465016
R6906 69 6 1.8584911678368492
R6907 69 7 0.9376314304260576
R6908 69 8 0.23603342560161356
R6909 69 9 0.8065861041111106
R6910 69 10 0.9296464545820722
R6911 69 11 0.9444328808516551
R6912 69 12 0.745138299782781
R6913 69 13 0.701827775488824
R6914 69 14 1.2458008759273265
R6915 69 15 0.4067077819561443
R6916 69 16 1.0455139469445078
R6917 69 17 1.120996246130158
R6918 69 18 1.0913570428774402
R6919 69 19 1.3026103020697195
R6920 69 20 0.9738761258950828
R6921 69 21 0.6241668247540365
R6922 69 22 0.9175408441637751
R6923 69 23 0.6621436293010183
R6924 69 24 0.5305773725556533
R6925 69 25 1.8314547627084967
R6926 69 26 1.425082458405957
R6927 69 27 1.0280153285022857
R6928 69 28 0.9662743322928709
R6929 69 29 1.118218644797813
R6930 69 30 0.6880969365627991
R6931 69 31 0.7795243098875306
R6932 69 32 0.5653814143418223
R6933 69 33 0.9526148132580923
R6934 69 34 0.8883400951124415
R6935 69 35 0.8876432201829042
R6936 69 36 0.934765464288023
R6937 69 37 1.4373643561637075
R6938 69 38 0.9280155880582186
R6939 69 39 1.4515591256020746
R6940 69 40 0.5804655817524375
R6941 69 41 0.33792626892296607
R6942 69 42 0.8610153811122322
R6943 69 43 0.7724386775391265
R6944 69 44 1.7497781931075695
R6945 69 45 0.45941886649131525
R6946 69 46 1.1340988545119235
R6947 69 47 1.4036025515763852
R6948 69 48 0.38327360316799963
R6949 69 49 1.4570841554557816
R6950 69 50 0.7234189622108632
R6951 69 51 1.3571478747640588
R6952 69 52 0.9537940702647358
R6953 69 53 1.2773803783916147
R6954 69 54 1.4174600636634458
R6955 69 55 1.034216332557874
R6956 69 56 0.9020498318833566
R6957 69 57 0.20705357918985878
R6958 69 58 0.9926493776607491
R6959 69 59 0.9798563344800335
R6960 69 60 0.9951691544952619
R6961 69 61 1.274469413666651
R6962 69 62 0.8860965406669953
R6963 69 63 0.8002150711842055
R6964 69 64 0.8587329096082024
R6965 69 65 1.2218537721953542
R6966 69 66 0.5259298824851739
R6967 69 67 0.7591015975769602
R6968 69 68 1.4194702542141087
R7000 70 0 0.6119812875863224
R7001 70 1 0.9659900972249544
R7002 70 2 1.2947389583272035
R7003 70 3 1.0839263706499112
R7004 70 4 0.6348639204954435
R7005 70 5 1.1437136397177285
R7006 70 6 0.9906357361219007
R7007 70 7 1.1734272301146258
R7008 70 8 0.5903020238075618
R7009 70 9 1.1300351344127715
R7010 70 10 1.2657619522293562
R7011 70 11 0.4690647930547379
R7012 70 12 0.3281780135111223
R7013 70 13 1.1013232167770686
R7014 70 14 1.1346728791358505
R7015 70 15 1.4464793884454523
R7016 70 16 1.2103459440963533
R7017 70 17 1.0328446608577915
R7018 70 18 0.8304072985217736
R7019 70 19 1.5601490136339122
R7020 70 20 0.998369137330508
R7021 70 21 1.4816579876924467
R7022 70 22 1.3545980756741223
R7023 70 23 0.633223118749975
R7024 70 24 1.3769213645996108
R7025 70 25 1.0803736059915112
R7026 70 26 0.7667759045169196
R7027 70 27 0.9268818843446981
R7028 70 28 0.9962330375707492
R7029 70 29 0.979066169923719
R7030 70 30 0.8921836322116277
R7031 70 31 1.1818287972082002
R7032 70 32 1.6829263635977965
R7033 70 33 1.4377942171203857
R7034 70 34 1.4560802635114882
R7035 70 35 1.6401100278613407
R7036 70 36 1.6153426713449692
R7037 70 37 1.477471225447328
R7038 70 38 0.4227617093927881
R7039 70 39 0.7822311615652175
R7040 70 40 1.313558777218013
R7041 70 41 1.050906631674718
R7042 70 42 1.548109447422681
R7043 70 43 1.1711248560494665
R7044 70 44 0.41338546680950927
R7045 70 45 0.4451105978381258
R7046 70 46 1.284781643273452
R7047 70 47 0.9405985021395314
R7048 70 48 0.4383436600523596
R7049 70 49 1.488090111746184
R7050 70 50 1.2194968866650147
R7051 70 51 0.03740261313709936
R7052 70 52 0.8954408070211147
R7053 70 53 0.9239616126574516
R7054 70 54 1.0279717622047526
R7055 70 55 1.3463131193226217
R7056 70 56 1.1268658926114359
R7057 70 57 0.9328174528508063
R7058 70 58 1.126197312591899
R7059 70 59 0.9342234836603065
R7060 70 60 1.3772564715322018
R7061 70 61 0.9847276555445363
R7062 70 62 0.7644176687526069
R7063 70 63 1.2036008765062336
R7064 70 64 1.306485540956749
R7065 70 65 1.097525090494217
R7066 70 66 1.5286349903879777
R7067 70 67 1.0453473224595928
R7068 70 68 1.083038825926701
R7069 70 69 0.010356715428072816
R7100 71 0 0.9398159894598912
R7101 71 1 1.0834975904358277
R7102 71 2 0.872966292469373
R7103 71 3 0.4576601923499184
R7104 71 4 1.1577538248302903
R7105 71 5 1.162930576601065
R7106 71 6 0.6079723479933661
R7107 71 7 0.8585913705328151
R7108 71 8 0.5326467359687163
R7109 71 9 1.51549497208253
R7110 71 10 1.4769306820797392
R7111 71 11 1.344640123720156
R7112 71 12 1.7125772578535687
R7113 71 13 1.3359206277402307
R7114 71 14 0.910528479345551
R7115 71 15 0.9035949602661766
R7116 71 16 0.8353286825915313
R7117 71 17 1.3497253007163825
R7118 71 18 1.2127537101361856
R7119 71 19 1.395481236203893
R7120 71 20 0.8484419728968152
R7121 71 21 0.8502751101178405
R7122 71 22 0.7640883409613088
R7123 71 23 1.4910980804247373
R7124 71 24 0.6366731908234728
R7125 71 25 0.5470980971228042
R7126 71 26 0.9030539997756615
R7127 71 27 0.5500338262236837
R7128 71 28 1.0697185054091607
R7129 71 29 1.3275979906951814
R7130 71 30 1.4386233061950637
R7131 71 31 0.9592552572316448
R7132 71 32 1.377382680069064
R7133 71 33 1.2953802762653743
R7134 71 34 1.1379820949510409
R7135 71 35 0.7922644758171106
R7136 71 36 1.1515484837186234
R7137 71 37 0.7695905669534103
R7138 71 38 1.332535645624661
R7139 71 39 0.959019617761563
R7140 71 40 1.0029964045616706
R7141 71 41 0.5629668103671719
R7142 71 42 0.3390750113600429
R7143 71 43 0.7471424730745129
R7144 71 44 1.891707181643723
R7145 71 45 1.3019269532372624
R7146 71 46 0.6496048568060085
R7147 71 47 0.416488863938958
R7148 71 48 1.0180196455964488
R7149 71 49 1.1607535286521915
R7150 71 50 1.140114164171294
R7151 71 51 1.1378159055867296
R7152 71 52 0.804155902666348
R7153 71 53 1.7071473107615456
R7154 71 54 1.5000487656689976
R7155 71 55 0.3990893877689632
R7156 71 56 1.5933397828304674
R7157 71 57 0.7453780879166649
R7158 71 58 1.2418422933065605
R7159 71 59 1.1595772436175404
R7160 71 60 1.1745912091504889
R7161 71 61 1.441562548974351
R7162 71 62 1.2043002064664403
R7163 71 63 0.7189041956758514
R7164 71 64 0.35189582128202146
R7165 71 65 0.5127786458037494
R7166 71 66 0.5072378924582943
R7167 71 67 0.9191899621457766
R7168 71 68 0.752750370617625
R7169 71 69 1.7181858886375012
R7170 71 70 1.2975577554206832
R7200 72 0 0.6812392044274354
R7201 72 1 1.8156075027318397
R7202 72 2 1.6099866383391026
R7203 72 3 1.9222673471008294
R7204 72 4 0.16105888000462754
R7205 72 5 0.2816335095796372
R7206 72 6 1.1118707772403984
R7207 72 7 0.22981880433806567
R7208 72 8 0.45812181887949655
R7209 72 9 1.3138366195689946
R7210 72 10 1.5690840625722684
R7211 72 11 1.0962348482226933
R7212 72 12 1.0680295037832608
R7213 72 13 0.7092180849668002
R7214 72 14 1.2553162431245903
R7215 72 15 0.030171647004018753
R7216 72 16 1.0513506613581898
R7217 72 17 1.6167980297889661
R7218 72 18 1.4727563811119389
R7219 72 19 1.2635698685742205
R7220 72 20 1.337333110053229
R7221 72 21 0.9860182095850061
R7222 72 22 0.8906334022113416
R7223 72 23 0.8427345642778256
R7224 72 24 0.7114665844015943
R7225 72 25 1.5193526380491922
R7226 72 26 0.8485249333552242
R7227 72 27 0.962380892758779
R7228 72 28 0.9695545347779688
R7229 72 29 0.7276512779667064
R7230 72 30 1.0931612275843032
R7231 72 31 0.9282822215379051
R7232 72 32 1.5351239949409554
R7233 72 33 0.7059885963536129
R7234 72 34 0.6538951536714039
R7235 72 35 1.3212813229077764
R7236 72 36 1.1512640580248779
R7237 72 37 1.1937085449841125
R7238 72 38 1.896756886108077
R7239 72 39 0.5106075526963977
R7240 72 40 1.1410603935286012
R7241 72 41 0.20701430095924123
R7242 72 42 0.7515723845176316
R7243 72 43 0.8910332505613999
R7244 72 44 0.5988787721065558
R7245 72 45 0.3335818235628022
R7246 72 46 1.5993084307005712
R7247 72 47 0.8565772429848862
R7248 72 48 1.3597679544595844
R7249 72 49 1.8755795087708715
R7250 72 50 0.6956046320257087
R7251 72 51 0.707364928271389
R7252 72 52 0.33216022670050016
R7253 72 53 0.44422721741626137
R7254 72 54 1.1395601496198375
R7255 72 55 0.926123357965082
R7256 72 56 1.811751549930647
R7257 72 57 0.5812103363298098
R7258 72 58 0.9158706495141823
R7259 72 59 1.1334846720737128
R7260 72 60 1.064646085934648
R7261 72 61 1.2380171547257566
R7262 72 62 0.19416094575852727
R7263 72 63 0.8829172308671124
R7264 72 64 1.1940492465223669
R7265 72 65 0.9442308604916186
R7266 72 66 1.176089131344305
R7267 72 67 1.028395636474106
R7268 72 68 0.5115439707448866
R7269 72 69 1.1567838720865922
R7270 72 70 1.5241663502317506
R7271 72 71 1.881755374841105
R7300 73 0 0.999600354878385
R7301 73 1 0.7127688531759693
R7302 73 2 0.8012782997441799
R7303 73 3 1.5457753640420924
R7304 73 4 1.6597065030245175
R7305 73 5 0.9133067923396013
R7306 73 6 0.8421793716237859
R7307 73 7 0.8658955917765009
R7308 73 8 0.738848891360296
R7309 73 9 0.2915978741842694
R7310 73 10 1.0349716144593926
R7311 73 11 0.5117645092650882
R7312 73 12 1.3023182208502035
R7313 73 13 1.2458492630601414
R7314 73 14 1.0259334475500461
R7315 73 15 0.3836828261822687
R7316 73 16 0.4114768904507923
R7317 73 17 1.0424767112890923
R7318 73 18 1.4098388040357333
R7319 73 19 0.041394504501286344
R7320 73 20 1.0001308807923732
R7321 73 21 1.2462699514795215
R7322 73 22 1.5544167532010946
R7323 73 23 0.5137307961885641
R7324 73 24 1.4338938299599797
R7325 73 25 0.5908406064762738
R7326 73 26 0.8656071597374139
R7327 73 27 1.0105600085989779
R7328 73 28 1.45837577671004
R7329 73 29 0.7782116233999856
R7330 73 30 0.4916817869029072
R7331 73 31 1.7102115149517285
R7332 73 32 1.3397633483138311
R7333 73 33 1.5898531198656627
R7334 73 34 1.2319492395367648
R7335 73 35 0.717745279808923
R7336 73 36 0.48751707880630835
R7337 73 37 1.396805580588472
R7338 73 38 0.3987538022545464
R7339 73 39 0.515712612588174
R7340 73 40 1.2754371484856195
R7341 73 41 1.2535433554172537
R7342 73 42 0.777314236480793
R7343 73 43 1.573354414634057
R7344 73 44 0.2554415737541561
R7345 73 45 0.8117217285769135
R7346 73 46 0.32800619529576325
R7347 73 47 1.2113776365215152
R7348 73 48 1.5863623329793428
R7349 73 49 1.1758873670203487
R7350 73 50 1.7244743283808157
R7351 73 51 0.5273499193349368
R7352 73 52 0.20659751199142373
R7353 73 53 1.2350896340918134
R7354 73 54 0.2150347908488377
R7355 73 55 0.6227845538764826
R7356 73 56 1.7263989018910244
R7357 73 57 0.6755042572923404
R7358 73 58 1.3352847702333188
R7359 73 59 1.6923647920699305
R7360 73 60 1.0922064149994584
R7361 73 61 1.4090540968826109
R7362 73 62 0.8238078136666364
R7363 73 63 1.6689593776138683
R7364 73 64 1.2403908073268535
R7365 73 65 1.6045569958632855
R7366 73 66 0.8375361707129522
R7367 73 67 1.6772972893339246
R7368 73 68 1.3294038375700326
R7369 73 69 0.3090324445442293
R7370 73 70 1.079544273983494
R7371 73 71 0.9499937407374545
R7372 73 72 1.5095188304049418
R7400 74 0 0.6656424444773094
R7401 74 1 1.2195247441351746
R7402 74 2 1.7030681103180985
R7403 74 3 0.9630475808842187
R7404 74 4 1.56590391827199
R7405 74 5 0.8354997104724539
R7406 74 6 0.6528773642764791
R7407 74 7 1.3729385618053191
R7408 74 8 1.762517708369123
R7409 74 9 1.1115607603797044
R7410 74 10 1.7559701990775556
R7411 74 11 1.5930742925104018
R7412 74 12 0.7871424566339288
R7413 74 13 1.692468567046488
R7414 74 14 0.1746394593985755
R7415 74 15 1.299026583815345
R7416 74 16 1.0511727587525417
R7417 74 17 0.5103572773882652
R7418 74 18 1.1065733710355043
R7419 74 19 1.6204570012888504
R7420 74 20 1.2471599558459363
R7421 74 21 1.8100009829670998
R7422 74 22 1.3737824512946162
R7423 74 23 0.9562774186938213
R7424 74 24 1.8827441906626552
R7425 74 25 1.1274148517354492
R7426 74 26 0.5818410823472929
R7427 74 27 0.21518024263774727
R7428 74 28 1.3029225930235884
R7429 74 29 0.9057945167738424
R7430 74 30 0.3439414427959645
R7431 74 31 0.40374154195186485
R7432 74 32 0.9549769220230078
R7433 74 33 0.8122276156537025
R7434 74 34 0.6545015418559773
R7435 74 35 0.719908845500671
R7436 74 36 1.6076801529924167
R7437 74 37 0.6163506606292605
R7438 74 38 1.6314527048002265
R7439 74 39 0.8365149204672315
R7440 74 40 1.3475550822700209
R7441 74 41 0.8911642228158664
R7442 74 42 0.661896498052609
R7443 74 43 1.6359450971215348
R7444 74 44 1.27865798919393
R7445 74 45 0.6377572872917093
R7446 74 46 1.1822861600729184
R7447 74 47 0.7135966993658016
R7448 74 48 1.3578362793864702
R7449 74 49 0.8046929486187927
R7450 74 50 0.24237071363928075
R7451 74 51 0.9153473352536257
R7452 74 52 1.4773691738393389
R7453 74 53 0.9936604002991005
R7454 74 54 0.6931018303213022
R7455 74 55 0.3683295832778132
R7456 74 56 1.2114841947348685
R7457 74 57 1.0465079867783547
R7458 74 58 1.22751067143113
R7459 74 59 0.24987883244399534
R7460 74 60 0.19504687772966767
R7461 74 61 0.3663847934831418
R7462 74 62 0.34936385421596605
R7463 74 63 1.2919765238694896
R7464 74 64 1.1145992619639835
R7465 74 65 0.9680147031547751
R7466 74 66 1.0550959400420692
R7467 74 67 1.2325557356074417
R7468 74 68 1.1884462948912928
R7469 74 69 0.5893336490869181
R7470 74 70 1.6033362613465343
R7471 74 71 1.1998852843224634
R7472 74 72 1.1706674196696722
R7473 74 73 1.4091201234701387
R7500 75 0 1.203549070349948
R7501 75 1 1.020046348389287
R7502 75 2 0.9141220978999249
R7503 75 3 0.8462598910785177
R7504 75 4 0.8702289567572461
R7505 75 5 0.43929727784724315
R7506 75 6 0.8525350437073501
R7507 75 7 0.5410648036559947
R7508 75 8 0.965027959143346
R7509 75 9 1.5161550677322282
R7510 75 10 1.7287926615682485
R7511 75 11 1.4039643966457853
R7512 75 12 0.981288963432866
R7513 75 13 1.5912185809200423
R7514 75 14 1.7650333368213311
R7515 75 15 1.006434533972559
R7516 75 16 1.042129245111229
R7517 75 17 1.2369578980886087
R7518 75 18 0.7645160067348968
R7519 75 19 0.7606419027280938
R7520 75 20 0.38450811394543216
R7521 75 21 0.7227097519591447
R7522 75 22 1.0027264574714576
R7523 75 23 0.5264292355687694
R7524 75 24 1.134304725192913
R7525 75 25 1.4982499687048034
R7526 75 26 1.0563676020595927
R7527 75 27 0.9890918789378086
R7528 75 28 0.8840476862469301
R7529 75 29 0.6588640474077591
R7530 75 30 0.33875609803849593
R7531 75 31 0.68706572732167
R7532 75 32 0.6960381145650575
R7533 75 33 1.2928556753611948
R7534 75 34 1.126166597096499
R7535 75 35 0.7388200717497398
R7536 75 36 0.8253144444255298
R7537 75 37 1.1666338126641052
R7538 75 38 0.964279997208367
R7539 75 39 0.7055569324285687
R7540 75 40 1.5952485736260182
R7541 75 41 1.213265141663733
R7542 75 42 1.5689616588800561
R7543 75 43 0.9372191720501243
R7544 75 44 0.6406394343818277
R7545 75 45 0.6560946659993385
R7546 75 46 0.7046675053221694
R7547 75 47 0.7253634813119819
R7548 75 48 0.9325033845031923
R7549 75 49 1.0824949668492616
R7550 75 50 1.028350441140284
R7551 75 51 0.8542421981088517
R7552 75 52 0.8020345311497713
R7553 75 53 0.8262661522710859
R7554 75 54 1.0636391427321605
R7555 75 55 0.48858302765453165
R7556 75 56 1.8258294220222333
R7557 75 57 0.6479637834094526
R7558 75 58 1.4290555984870439
R7559 75 59 0.4473642144601385
R7560 75 60 1.00045721582309
R7561 75 61 0.950870857134009
R7562 75 62 0.750433768497154
R7563 75 63 0.6628600899262036
R7564 75 64 0.6645935727070502
R7565 75 65 1.1996536496077181
R7566 75 66 1.3891169123666889
R7567 75 67 0.036678252796903066
R7568 75 68 1.3599895267261235
R7569 75 69 1.1720999881220013
R7570 75 70 0.9884671419796361
R7571 75 71 0.7970382058175091
R7572 75 72 0.4961354295911201
R7573 75 73 1.0363202983157707
R7574 75 74 0.22684634231675505
R7600 76 0 1.2590439235026287
R7601 76 1 1.075543713627386
R7602 76 2 0.6215258925773692
R7603 76 3 1.1522273495236348
R7604 76 4 0.6378735333907583
R7605 76 5 1.4006083741916833
R7606 76 6 1.4971003255525406
R7607 76 7 1.3911259942182173
R7608 76 8 1.070140908107986
R7609 76 9 1.3583078519058183
R7610 76 10 0.37320982588949925
R7611 76 11 1.8314463014255442
R7612 76 12 0.7207698102666272
R7613 76 13 0.16472431570617996
R7614 76 14 0.27255978725597974
R7615 76 15 1.416437812525278
R7616 76 16 0.9481404569804941
R7617 76 17 0.5476114510380585
R7618 76 18 1.2365584883818541
R7619 76 19 0.5590613317325205
R7620 76 20 0.6103467142008008
R7621 76 21 0.8929398363991007
R7622 76 22 1.3584303664658082
R7623 76 23 1.013208935391868
R7624 76 24 0.3896577257968603
R7625 76 25 1.1280300071139164
R7626 76 26 0.24722741766463185
R7627 76 27 1.4320624433068287
R7628 76 28 0.8261977013332387
R7629 76 29 0.720972646050131
R7630 76 30 1.1122680140063732
R7631 76 31 0.7368883459596998
R7632 76 32 1.2150107410546562
R7633 76 33 1.5351161603730423
R7634 76 34 0.8821434514889426
R7635 76 35 1.3702788136337323
R7636 76 36 0.8935309665515765
R7637 76 37 1.1869890027754124
R7638 76 38 0.9623288969626566
R7639 76 39 1.3256453203262777
R7640 76 40 0.9141153634412696
R7641 76 41 1.204804356007609
R7642 76 42 1.392790264875368
R7643 76 43 1.5467429580449799
R7644 76 44 1.4547632086570115
R7645 76 45 1.1139422520350428
R7646 76 46 0.9555526962108932
R7647 76 47 0.5170914856753818
R7648 76 48 0.8057384822229493
R7649 76 49 0.959755705857471
R7650 76 50 1.1012344789567994
R7651 76 51 1.2478508197532752
R7652 76 52 0.6731587245469886
R7653 76 53 0.5644013698730271
R7654 76 54 1.3306437476226693
R7655 76 55 0.724245577189181
R7656 76 56 1.0094398586218838
R7657 76 57 1.0112255644483525
R7658 76 58 0.10534674116709819
R7659 76 59 1.874098273241445
R7660 76 60 1.709518679824272
R7661 76 61 0.500591638547501
R7662 76 62 0.2564531430358912
R7663 76 63 0.6527822213872856
R7664 76 64 1.0770920723140507
R7665 76 65 1.0020087064738878
R7666 76 66 0.48212493533702816
R7667 76 67 1.457059415703882
R7668 76 68 1.4801663499503617
R7669 76 69 1.8008280148000697
R7670 76 70 1.746618995230886
R7671 76 71 0.8729475454570677
R7672 76 72 0.4467137798002131
R7673 76 73 0.7130662025065604
R7674 76 74 0.5829681858345231
R7675 76 75 0.4369430509682639
R7700 77 0 1.3997964095981505
R7701 77 1 1.3754549378560617
R7702 77 2 1.1331670215696148
R7703 77 3 0.9561799814619556
R7704 77 4 1.3072559625904665
R7705 77 5 1.3964370803939827
R7706 77 6 1.095652329947883
R7707 77 7 0.5302631316479047
R7708 77 8 0.42008913203262466
R7709 77 9 1.0280517332514616
R7710 77 10 0.9098313712151451
R7711 77 11 0.8838176059984374
R7712 77 12 0.4325288347608133
R7713 77 13 1.5128638886169763
R7714 77 14 1.2524251865190013
R7715 77 15 0.4516979648413678
R7716 77 16 0.5508973380415778
R7717 77 17 1.3369599242256442
R7718 77 18 0.6216722755960226
R7719 77 19 1.5466514279798191
R7720 77 20 1.1225258032119072
R7721 77 21 0.7814196465603056
R7722 77 22 1.3138281376664238
R7723 77 23 0.8717414992529061
R7724 77 24 1.0408525130057122
R7725 77 25 1.6451959923407369
R7726 77 26 0.9688741705024874
R7727 77 27 1.0435963579729872
R7728 77 28 1.555804985648256
R7729 77 29 1.154354497818964
R7730 77 30 1.090021409394493
R7731 77 31 0.9189813965587815
R7732 77 32 0.9464460385033657
R7733 77 33 0.81371666335678
R7734 77 34 1.5461779354943284
R7735 77 35 1.1713136365289936
R7736 77 36 0.8726710188597857
R7737 77 37 0.808381547502855
R7738 77 38 1.0349482955078462
R7739 77 39 1.0656262136440258
R7740 77 40 1.4755472489100412
R7741 77 41 0.9241786598370849
R7742 77 42 0.9096536951526533
R7743 77 43 0.48619734593502606
R7744 77 44 0.4758512031654273
R7745 77 45 0.9967627965188489
R7746 77 46 0.6864236944118691
R7747 77 47 0.9972059465216059
R7748 77 48 1.2112237879570613
R7749 77 49 0.44793068846892303
R7750 77 50 1.1526865185658715
R7751 77 51 1.4628592013341013
R7752 77 52 1.1198625104359325
R7753 77 53 1.6155076027614432
R7754 77 54 0.6813830781087131
R7755 77 55 0.7362531403274548
R7756 77 56 1.0216861864275992
R7757 77 57 0.08485779965565388
R7758 77 58 0.8791917307764505
R7759 77 59 1.680264583695923
R7760 77 60 0.7430266405319581
R7761 77 61 1.2172875114116548
R7762 77 62 1.0205551625374194
R7763 77 63 0.5554414107879111
R7764 77 64 1.0695091740174414
R7765 77 65 0.9341018924403072
R7766 77 66 0.17167872736230128
R7767 77 67 0.5953304118584538
R7768 77 68 1.1165834328671451
R7769 77 69 1.1318344452164841
R7770 77 70 0.8775052085217208
R7771 77 71 0.6461705392276721
R7772 77 72 0.6076484955798922
R7773 77 73 1.1850355752173707
R7774 77 74 1.6960238941296955
R7775 77 75 0.7098956761836707
R7776 77 76 0.17718235241811398
R7800 78 0 1.4826214481585067
R7801 78 1 0.601815440156025
R7802 78 2 0.7849685028899709
R7803 78 3 1.097099945369624
R7804 78 4 0.6429420332918774
R7805 78 5 0.7071337884778532
R7806 78 6 1.741739085597246
R7807 78 7 0.8061502357197914
R7808 78 8 0.40920528126382805
R7809 78 9 0.17732329133839908
R7810 78 10 1.317303276969397
R7811 78 11 1.446270811782255
R7812 78 12 1.0793184182785363
R7813 78 13 1.2285212962889622
R7814 78 14 1.1480728435394094
R7815 78 15 0.6938246755594658
R7816 78 16 0.6830152276094237
R7817 78 17 1.2453117785841417
R7818 78 18 1.2876545502529582
R7819 78 19 1.301086960368228
R7820 78 20 0.43089299775770273
R7821 78 21 0.7997810611275575
R7822 78 22 0.5860080995060702
R7823 78 23 1.4423034615302308
R7824 78 24 1.5932658583145192
R7825 78 25 1.018914568382777
R7826 78 26 1.9471799498741271
R7827 78 27 0.9568678546685601
R7828 78 28 1.1263364675085594
R7829 78 29 1.5761971766805591
R7830 78 30 0.3068141487268867
R7831 78 31 1.003102352507196
R7832 78 32 1.434255120844952
R7833 78 33 1.034603138876316
R7834 78 34 0.8284722363519721
R7835 78 35 1.3400819506046786
R7836 78 36 0.9530649243309983
R7837 78 37 0.3236006698061351
R7838 78 38 0.3159943607147463
R7839 78 39 0.9454272787369489
R7840 78 40 1.2154515222337037
R7841 78 41 0.9919980350836134
R7842 78 42 1.2293201554753126
R7843 78 43 0.45355141274099986
R7844 78 44 0.5859262941043156
R7845 78 45 0.9316280098053991
R7846 78 46 0.6461724940172466
R7847 78 47 1.2191681728693982
R7848 78 48 1.1434898595845613
R7849 78 49 1.3761794981260396
R7850 78 50 1.2673943895212028
R7851 78 51 0.4306550410472949
R7852 78 52 1.05123153660494
R7853 78 53 1.3686853744654497
R7854 78 54 0.8629724807021669
R7855 78 55 0.9944009357135337
R7856 78 56 0.5875770326180528
R7857 78 57 1.249103745328311
R7858 78 58 0.4504764933172164
R7859 78 59 0.48745132523575685
R7860 78 60 0.9094109284485795
R7861 78 61 1.6781899607137292
R7862 78 62 1.3247209550681356
R7863 78 63 1.4314704182791365
R7864 78 64 0.9537044318224736
R7865 78 65 1.0467532025193491
R7866 78 66 0.6536786958150874
R7867 78 67 1.0730680800428356
R7868 78 68 0.5989781256728195
R7869 78 69 0.6372995732422212
R7870 78 70 0.9808992328019511
R7871 78 71 1.0247252224995371
R7872 78 72 0.6121115627478805
R7873 78 73 1.0398164984407932
R7874 78 74 0.424289902896401
R7875 78 75 1.0269989832195838
R7876 78 76 0.6230433918424798
R7877 78 77 1.0288395360530571
R7900 79 0 1.1141210540674522
R7901 79 1 0.4982242883869462
R7902 79 2 1.0448574431799167
R7903 79 3 0.9920589486586429
R7904 79 4 0.840233792583116
R7905 79 5 1.4110281796964097
R7906 79 6 1.687101520544429
R7907 79 7 0.7594451963503438
R7908 79 8 0.6171072284613756
R7909 79 9 0.3977156651645847
R7910 79 10 1.13023288752628
R7911 79 11 1.0585249070634166
R7912 79 12 1.1893833009782706
R7913 79 13 1.710501894855645
R7914 79 14 0.728964821329999
R7915 79 15 0.5655274203969674
R7916 79 16 0.7315252023689601
R7917 79 17 0.3381455603030148
R7918 79 18 1.0573322750845358
R7919 79 19 1.2455688384016257
R7920 79 20 1.1467278874511178
R7921 79 21 1.1101873000958653
R7922 79 22 1.6570376777219287
R7923 79 23 1.2881690396764947
R7924 79 24 0.7931333516737116
R7925 79 25 1.6801077910222033
R7926 79 26 1.1814063982749399
R7927 79 27 0.9828056408758001
R7928 79 28 1.1045917464741826
R7929 79 29 1.6534132115235178
R7930 79 30 0.9391371020542629
R7931 79 31 0.9799553816932449
R7932 79 32 0.4463359371690161
R7933 79 33 1.242476396548331
R7934 79 34 1.661779864114934
R7935 79 35 0.8011718057216791
R7936 79 36 1.3701567675478175
R7937 79 37 1.7312373250653024
R7938 79 38 1.291026372744454
R7939 79 39 0.7090044596062156
R7940 79 40 1.7838078195359512
R7941 79 41 0.6067528946459845
R7942 79 42 1.3609832504526103
R7943 79 43 1.4452330832008669
R7944 79 44 1.1786212820393427
R7945 79 45 0.3864048008197757
R7946 79 46 0.6206805902837121
R7947 79 47 1.3941365195252295
R7948 79 48 1.1385645426811444
R7949 79 49 0.42466716726551335
R7950 79 50 0.6483852138044484
R7951 79 51 0.5987523086076402
R7952 79 52 1.0153649786356889
R7953 79 53 0.615583041433087
R7954 79 54 1.0308872108826121
R7955 79 55 1.4927364770894305
R7956 79 56 1.0881511718756023
R7957 79 57 0.48124876803632266
R7958 79 58 1.7990531142620179
R7959 79 59 0.8016379678424087
R7960 79 60 0.32003387031246955
R7961 79 61 0.7046928150161309
R7962 79 62 1.3514390365514446
R7963 79 63 0.5423166726301242
R7964 79 64 0.19306494586113143
R7965 79 65 0.5829380598498821
R7966 79 66 0.8901830973710584
R7967 79 67 1.6414096999342926
R7968 79 68 1.13501336414711
R7969 79 69 0.8836753890771757
R7970 79 70 1.5675541132320494
R7971 79 71 0.6237910313552141
R7972 79 72 1.4579309274076044
R7973 79 73 0.08212106584715739
R7974 79 74 1.3757944265317203
R7975 79 75 0.7279825791488233
R7976 79 76 0.7426201168547079
R7977 79 77 0.8382228219673955
R7978 79 78 1.1140756939034997
R8000 80 0 0.6450818224090366
R8001 80 1 1.0680375261786779
R8002 80 2 0.9826270028217039
R8003 80 3 0.9613170305069504
R8004 80 4 1.3907500898926974
R8005 80 5 1.2043161150288917
R8006 80 6 1.2014022551087558
R8007 80 7 0.4762879445606796
R8008 80 8 1.0465574035248926
R8009 80 9 0.7169745891872594
R8010 80 10 1.290931907254357
R8011 80 11 0.7145719919075018
R8012 80 12 1.0577532305945694
R8013 80 13 0.2954920547808356
R8014 80 14 0.9037308062642068
R8015 80 15 1.1118518595733415
R8016 80 16 0.4703150175489873
R8017 80 17 1.5375996479991634
R8018 80 18 1.02225852844089
R8019 80 19 0.47455253133098474
R8020 80 20 0.28984411365528173
R8021 80 21 0.172601018327173
R8022 80 22 1.0467469573859054
R8023 80 23 1.3704713512294917
R8024 80 24 0.7169980413471423
R8025 80 25 1.6669899677466928
R8026 80 26 0.7337887171147621
R8027 80 27 1.8371213901936594
R8028 80 28 1.0246164661369177
R8029 80 29 0.9009086444561565
R8030 80 30 0.4786139619769463
R8031 80 31 0.4152879519232757
R8032 80 32 1.5321670187738718
R8033 80 33 1.4233290820807765
R8034 80 34 1.0282904947807467
R8035 80 35 1.451057372756638
R8036 80 36 0.6339125396727698
R8037 80 37 0.7871126845103591
R8038 80 38 0.3900502354364511
R8039 80 39 0.8575165892854725
R8040 80 40 1.073675656857287
R8041 80 41 1.3461139220467415
R8042 80 42 1.2917348357551313
R8043 80 43 0.6339217191792993
R8044 80 44 0.754477017214225
R8045 80 45 1.2032135009292926
R8046 80 46 0.808348293890138
R8047 80 47 0.730390646884358
R8048 80 48 0.6621295576982732
R8049 80 49 0.6391122436183997
R8050 80 50 1.762244387194058
R8051 80 51 1.0119127325572352
R8052 80 52 1.3930038798183841
R8053 80 53 1.1198230519423418
R8054 80 54 1.0714588167314911
R8055 80 55 1.6277401175953519
R8056 80 56 0.6176092986730257
R8057 80 57 1.2624664519508892
R8058 80 58 1.756212754063528
R8059 80 59 1.1744412389297767
R8060 80 60 0.7665051701216974
R8061 80 61 1.392504765576511
R8062 80 62 1.2988864935113957
R8063 80 63 0.5493311083831947
R8064 80 64 1.2417616397655298
R8065 80 65 0.8599027735263716
R8066 80 66 0.4206204127260016
R8067 80 67 1.7776690967349442
R8068 80 68 1.0018591869641895
R8069 80 69 0.5871162043152481
R8070 80 70 0.3926849258001832
R8071 80 71 1.459130987372371
R8072 80 72 0.958290664383613
R8073 80 73 1.6345973215179304
R8074 80 74 1.7213969883334481
R8075 80 75 0.9870944312032833
R8076 80 76 0.7125513766883785
R8077 80 77 1.2787865133960812
R8078 80 78 1.150781408135408
R8079 80 79 1.3604804899153784
R8100 81 0 1.2189111648689863
R8101 81 1 1.5630384028001438
R8102 81 2 1.2355469737192635
R8103 81 3 1.2039346274619407
R8104 81 4 1.1663949920653067
R8105 81 5 0.4913477618513493
R8106 81 6 1.1365966583304403
R8107 81 7 1.7367427287692472
R8108 81 8 1.2861084377392251
R8109 81 9 0.13804108705866813
R8110 81 10 1.4098199228772628
R8111 81 11 1.29289775320508
R8112 81 12 1.306805437534621
R8113 81 13 1.0419257497229375
R8114 81 14 1.392670543993344
R8115 81 15 1.5071540188705117
R8116 81 16 1.628967086645686
R8117 81 17 1.1856165006095158
R8118 81 18 0.42770524712980573
R8119 81 19 1.455604659150668
R8120 81 20 1.2960810572732866
R8121 81 21 0.5122572322230347
R8122 81 22 1.4809956485036382
R8123 81 23 0.5721632914956887
R8124 81 24 0.9470568424229417
R8125 81 25 0.5312852406112244
R8126 81 26 0.5549753703618366
R8127 81 27 0.4925396639820907
R8128 81 28 0.3778127567820593
R8129 81 29 0.9414425575857169
R8130 81 30 1.3182346248989072
R8131 81 31 0.765931208553807
R8132 81 32 1.6938382053639418
R8133 81 33 1.2741149317247529
R8134 81 34 1.1431315712084902
R8135 81 35 1.7696753225101554
R8136 81 36 1.3231329132028664
R8137 81 37 0.5768414065451354
R8138 81 38 0.19683138098871256
R8139 81 39 0.6748771559428819
R8140 81 40 1.6092283783655872
R8141 81 41 1.1000851384835482
R8142 81 42 0.6842531747929733
R8143 81 43 0.6280887223781744
R8144 81 44 1.098632147723652
R8145 81 45 1.2472999933573854
R8146 81 46 1.0306624468809487
R8147 81 47 0.6974308723930197
R8148 81 48 1.1586781033497284
R8149 81 49 1.1031024858101448
R8150 81 50 0.8241317683561138
R8151 81 51 1.2876778394956205
R8152 81 52 1.284719781152246
R8153 81 53 1.607831180076479
R8154 81 54 0.8031333960963255
R8155 81 55 0.8633585946172209
R8156 81 56 0.5945053515207612
R8157 81 57 1.0587301483992024
R8158 81 58 0.7350613167371253
R8159 81 59 1.451949522568594
R8160 81 60 0.6437231537138888
R8161 81 61 0.8334385950812077
R8162 81 62 0.4062808091292601
R8163 81 63 1.6856525159658358
R8164 81 64 0.2727806998968402
R8165 81 65 0.6800825072366514
R8166 81 66 1.0092454601246468
R8167 81 67 1.0869903923936453
R8168 81 68 0.57883868604965
R8169 81 69 1.071703124377326
R8170 81 70 0.9577643763825994
R8171 81 71 1.3647595616457082
R8172 81 72 1.4922665862445248
R8173 81 73 0.2548662378080402
R8174 81 74 0.8531787023532745
R8175 81 75 1.5303193997288111
R8176 81 76 0.5511959014195246
R8177 81 77 1.4698748654106684
R8178 81 78 0.8380713151543423
R8179 81 79 0.886660757300111
R8180 81 80 0.9825619036744692
R8200 82 0 0.6846423146120386
R8201 82 1 0.8222738371937512
R8202 82 2 1.1959821278251939
R8203 82 3 0.9468363537347038
R8204 82 4 1.6198895463838539
R8205 82 5 0.914680653812803
R8206 82 6 1.0889667331590585
R8207 82 7 1.0184632731070948
R8208 82 8 0.5227724447262416
R8209 82 9 1.417946145945875
R8210 82 10 1.0747983797009
R8211 82 11 0.9937311283561409
R8212 82 12 0.46798067940084276
R8213 82 13 0.3977556486624403
R8214 82 14 0.4175415363479241
R8215 82 15 1.5658443120343768
R8216 82 16 1.448645202798898
R8217 82 17 0.9072723808034928
R8218 82 18 1.0388388862518392
R8219 82 19 1.5692026034506559
R8220 82 20 0.5006991524235449
R8221 82 21 0.9608450704010333
R8222 82 22 1.1599599118020043
R8223 82 23 0.6474227845284295
R8224 82 24 1.4674075752154958
R8225 82 25 1.0192186228946523
R8226 82 26 1.260499452991766
R8227 82 27 0.982160597030704
R8228 82 28 0.935675707548083
R8229 82 29 0.4214876856587516
R8230 82 30 1.407715960210468
R8231 82 31 0.6860804855702008
R8232 82 32 0.9062607768872899
R8233 82 33 1.1072564328029286
R8234 82 34 0.561553447522539
R8235 82 35 1.3840956742741484
R8236 82 36 0.446604068532822
R8237 82 37 1.0320283811536397
R8238 82 38 1.015107634569385
R8239 82 39 1.1933137969008083
R8240 82 40 1.2985746908469369
R8241 82 41 1.2657236384292165
R8242 82 42 0.4853584277890969
R8243 82 43 1.6053254325111552
R8244 82 44 0.6272996820963866
R8245 82 45 1.6869075929941562
R8246 82 46 1.1347188086493567
R8247 82 47 0.1069326124922132
R8248 82 48 0.6005132478433687
R8249 82 49 0.5007976691504549
R8250 82 50 1.3696370295407985
R8251 82 51 1.6319217271878215
R8252 82 52 1.2350628456073445
R8253 82 53 1.071375162002409
R8254 82 54 0.8347237001666143
R8255 82 55 1.097392578827861
R8256 82 56 1.6373826609840512
R8257 82 57 0.8449606634684969
R8258 82 58 0.6115407177942971
R8259 82 59 1.8301765638228198
R8260 82 60 1.2644527277557729
R8261 82 61 1.3507580921613438
R8262 82 62 0.4642269305102765
R8263 82 63 0.9390504321733693
R8264 82 64 0.7198287413427349
R8265 82 65 0.7202310121329476
R8266 82 66 0.9240332068964775
R8267 82 67 1.2410903635870028
R8268 82 68 1.0225090406418123
R8269 82 69 0.8089924289313507
R8270 82 70 0.9782087130223335
R8271 82 71 1.4880884599695388
R8272 82 72 0.3993870779516222
R8273 82 73 1.2211277551268678
R8274 82 74 1.307671682694694
R8275 82 75 1.350496682786095
R8276 82 76 0.6551169886354594
R8277 82 77 1.2563462292489906
R8278 82 78 0.6755088542735601
R8279 82 79 0.32372418570723394
R8280 82 80 1.7708999965184802
R8281 82 81 0.5222611570311007
R8300 83 0 1.7601046699689875
R8301 83 1 1.5412675957504174
R8302 83 2 1.0507126795577861
R8303 83 3 1.1852799148535844
R8304 83 4 0.9508807211650138
R8305 83 5 0.7066311154681075
R8306 83 6 1.5004326953328377
R8307 83 7 1.6968298015491883
R8308 83 8 1.5545486196722482
R8309 83 9 0.1897997484399403
R8310 83 10 0.36457088364090307
R8311 83 11 1.4270048921493848
R8312 83 12 0.4484397358760227
R8313 83 13 0.4827326592588771
R8314 83 14 0.7537001239769195
R8315 83 15 0.4672317895105458
R8316 83 16 1.5542956354272308
R8317 83 17 0.859517984089671
R8318 83 18 1.118323767717453
R8319 83 19 0.7250401595546709
R8320 83 20 0.7493435587109575
R8321 83 21 1.0933530103311635
R8322 83 22 1.1105050977507596
R8323 83 23 0.43253885515899226
R8324 83 24 1.3980901211902887
R8325 83 25 1.1681086865526868
R8326 83 26 0.7399636000445691
R8327 83 27 0.692509538209269
R8328 83 28 1.9633674426025207
R8329 83 29 1.1541051250498044
R8330 83 30 1.6494751506839485
R8331 83 31 1.0407423036532473
R8332 83 32 0.8497479016205246
R8333 83 33 0.3479745864167596
R8334 83 34 1.069844728274437
R8335 83 35 1.4772834386773286
R8336 83 36 0.9048133048451639
R8337 83 37 1.168480111851637
R8338 83 38 1.0592714052973142
R8339 83 39 1.0287038446173056
R8340 83 40 1.2264305740425272
R8341 83 41 0.7650722938777721
R8342 83 42 0.6809904221854947
R8343 83 43 1.03448589370386
R8344 83 44 0.7510907898004855
R8345 83 45 1.683497050714359
R8346 83 46 0.8929600275348222
R8347 83 47 1.0393337828267875
R8348 83 48 1.0662386131778123
R8349 83 49 0.7330897738898571
R8350 83 50 0.9088426756226886
R8351 83 51 0.9700185897301469
R8352 83 52 1.0523618517436817
R8353 83 53 0.7692285925044158
R8354 83 54 0.9611671534990379
R8355 83 55 1.7430229712518241
R8356 83 56 0.9127672225820674
R8357 83 57 0.9263764520448458
R8358 83 58 0.7640694286271944
R8359 83 59 1.6203043113054958
R8360 83 60 0.2676514077100133
R8361 83 61 1.4630779309834137
R8362 83 62 0.9273952585519257
R8363 83 63 1.2805365388300345
R8364 83 64 1.4566669215087544
R8365 83 65 1.3173878178786114
R8366 83 66 1.4466482642858491
R8367 83 67 0.8004190279914501
R8368 83 68 1.6125300173457107
R8369 83 69 1.6330393996639896
R8370 83 70 1.6514893241315134
R8371 83 71 1.07284181021485
R8372 83 72 0.9707462202033426
R8373 83 73 0.9973486126721972
R8374 83 74 1.3845385742716076
R8375 83 75 0.8443329017919645
R8376 83 76 0.48281011531242835
R8377 83 77 1.2073423276475774
R8378 83 78 1.436744228348823
R8379 83 79 1.2442745912569362
R8380 83 80 0.5315951050392438
R8381 83 81 1.7669187867476328
R8382 83 82 1.5223959456864182
R8400 84 0 1.3735369888952174
R8401 84 1 0.6752885742511343
R8402 84 2 1.342841931330808
R8403 84 3 1.0227035166900171
R8404 84 4 1.2734653447060724
R8405 84 5 1.3289114619765592
R8406 84 6 0.6979461513658495
R8407 84 7 1.0968904183760082
R8408 84 8 1.607979260949074
R8409 84 9 0.8722482862069925
R8410 84 10 0.8173715586640585
R8411 84 11 1.2993594462371898
R8412 84 12 1.5888016178260513
R8413 84 13 0.2615152433787036
R8414 84 14 1.0829000244114786
R8415 84 15 1.4743338442139935
R8416 84 16 0.6890725368800021
R8417 84 17 0.9155551673389907
R8418 84 18 0.9495083097513319
R8419 84 19 0.7181599538566632
R8420 84 20 0.487647393955586
R8421 84 21 0.9482026001516624
R8422 84 22 0.6972679023301385
R8423 84 23 0.6863604923515206
R8424 84 24 1.601566151190386
R8425 84 25 1.2900181532063422
R8426 84 26 1.9403058198471514
R8427 84 27 0.5830097031929278
R8428 84 28 1.1766882211863507
R8429 84 29 0.15733396861871252
R8430 84 30 1.248283540069714
R8431 84 31 0.04281392257784333
R8432 84 32 1.352069083483739
R8433 84 33 1.080164210701304
R8434 84 34 0.5861903703821559
R8435 84 35 0.30592859372862746
R8436 84 36 0.9992103735378453
R8437 84 37 1.4097298536006955
R8438 84 38 1.5176471161044494
R8439 84 39 1.1724526316191564
R8440 84 40 1.0601540550682316
R8441 84 41 0.2328215209356158
R8442 84 42 1.551331714837178
R8443 84 43 1.0948296569446039
R8444 84 44 0.6756538207421492
R8445 84 45 0.8291398031125758
R8446 84 46 0.3311948659618762
R8447 84 47 1.757560351942982
R8448 84 48 1.0228212503892418
R8449 84 49 1.6879258631318925
R8450 84 50 0.7185328947334853
R8451 84 51 1.1021832730122099
R8452 84 52 1.450502140553654
R8453 84 53 1.912062505579091
R8454 84 54 0.6012173714120963
R8455 84 55 1.1230072191369511
R8456 84 56 0.36352236154620765
R8457 84 57 0.8977316704475551
R8458 84 58 1.7603939069322
R8459 84 59 0.2050396647710021
R8460 84 60 0.6654591762426537
R8461 84 61 1.3023950704388858
R8462 84 62 0.5217163630905459
R8463 84 63 1.5539505878878996
R8464 84 64 0.29245979058510285
R8465 84 65 1.1756428794326652
R8466 84 66 0.8757561571044609
R8467 84 67 0.581222547233155
R8468 84 68 1.2851557427050873
R8469 84 69 0.8856349237082516
R8470 84 70 0.4262281249325609
R8471 84 71 1.153850634473324
R8472 84 72 1.4268807555412282
R8473 84 73 1.7350685737095164
R8474 84 74 0.8308483649802761
R8475 84 75 0.27009650640445404
R8476 84 76 0.9646979751714069
R8477 84 77 1.868214304992376
R8478 84 78 0.7653871502570693
R8479 84 79 0.3299139789524246
R8480 84 80 0.7000236450110561
R8481 84 81 1.500429443157957
R8482 84 82 0.6474386189791295
R8483 84 83 0.15108904487011188
R8500 85 0 0.895188996606251
R8501 85 1 0.7199345396512895
R8502 85 2 0.9228294557127062
R8503 85 3 1.1492863884346352
R8504 85 4 0.17540357359259484
R8505 85 5 0.9415260307608987
R8506 85 6 1.7094328755494783
R8507 85 7 0.23970308077209102
R8508 85 8 1.512926927932931
R8509 85 9 0.6548326651116124
R8510 85 10 0.7060583990535032
R8511 85 11 0.834930156603021
R8512 85 12 1.7722791411728505
R8513 85 13 0.8978540863606908
R8514 85 14 1.1438631630906912
R8515 85 15 1.11793215138166
R8516 85 16 0.8723449277780603
R8517 85 17 1.252947586991826
R8518 85 18 1.726951115343137
R8519 85 19 1.265399808193054
R8520 85 20 1.0432200779260454
R8521 85 21 0.8955985135647011
R8522 85 22 0.8761740129268122
R8523 85 23 0.8720362478919595
R8524 85 24 0.14733412272356328
R8525 85 25 0.9437050085096442
R8526 85 26 1.4943315083912623
R8527 85 27 0.5505137552704644
R8528 85 28 1.0951836786829818
R8529 85 29 1.3612461662812514
R8530 85 30 0.7835445008840416
R8531 85 31 0.9539010835051391
R8532 85 32 1.02311624022632
R8533 85 33 1.086485343128638
R8534 85 34 1.6370003769889123
R8535 85 35 1.217743457205903
R8536 85 36 1.9244473489971732
R8537 85 37 1.0741034467781634
R8538 85 38 0.8497381751531089
R8539 85 39 0.8302759263463827
R8540 85 40 1.7521240226027985
R8541 85 41 1.4199565410237636
R8542 85 42 0.4567682324297194
R8543 85 43 0.4875829581098937
R8544 85 44 0.9715385896311459
R8545 85 45 0.17944218073806228
R8546 85 46 0.8779942144429796
R8547 85 47 1.8199358355829545
R8548 85 48 0.9767980675621105
R8549 85 49 0.6699948805824918
R8550 85 50 0.21848228987169604
R8551 85 51 0.9254310908352167
R8552 85 52 1.0829288038479434
R8553 85 53 1.0737757545020346
R8554 85 54 0.8642386383809757
R8555 85 55 0.7877798820020877
R8556 85 56 1.4617796274012265
R8557 85 57 0.9197113180995705
R8558 85 58 1.5393556265710129
R8559 85 59 1.5895133249315916
R8560 85 60 0.12952425811557555
R8561 85 61 0.7406229532252974
R8562 85 62 0.6877776640745381
R8563 85 63 0.6904397062037498
R8564 85 64 0.6980370820942654
R8565 85 65 1.8955882505791464
R8566 85 66 0.8174745004419998
R8567 85 67 1.2785657169926778
R8568 85 68 0.3975066954762476
R8569 85 69 0.9401553915216949
R8570 85 70 0.9677899802065101
R8571 85 71 0.4876305979339245
R8572 85 72 1.38726460717643
R8573 85 73 0.31196494932487706
R8574 85 74 1.2831954396753735
R8575 85 75 1.2369104310582315
R8576 85 76 0.477180208496936
R8577 85 77 1.2147694175893167
R8578 85 78 0.8554949934225774
R8579 85 79 1.0177730032005214
R8580 85 80 0.40561654960534865
R8581 85 81 1.0021828917123794
R8582 85 82 1.8371331841611962
R8583 85 83 1.3788403825500635
R8584 85 84 0.5011988372901501
R8600 86 0 0.7874139610094558
R8601 86 1 0.539050544412819
R8602 86 2 0.7036122755255363
R8603 86 3 1.4663403905223689
R8604 86 4 1.74641995917816
R8605 86 5 0.1276835779180665
R8606 86 6 1.1810928033204533
R8607 86 7 0.7976554825141836
R8608 86 8 0.5669787167623233
R8609 86 9 1.313399733650481
R8610 86 10 1.065345774437144
R8611 86 11 0.8273917918388759
R8612 86 12 0.617432210330916
R8613 86 13 1.1309291004715885
R8614 86 14 1.2838697650297664
R8615 86 15 1.357922295629972
R8616 86 16 1.3959597528992955
R8617 86 17 0.3013874836843179
R8618 86 18 0.9754737929685792
R8619 86 19 0.7470578863353875
R8620 86 20 1.0160183846093591
R8621 86 21 1.3530681159134703
R8622 86 22 1.9552818894392485
R8623 86 23 1.5266925360650867
R8624 86 24 1.3124945561486805
R8625 86 25 0.31971233554255174
R8626 86 26 1.1390807637522884
R8627 86 27 1.2296011431978244
R8628 86 28 0.9424608722280486
R8629 86 29 0.7979743467047199
R8630 86 30 1.1599603075583829
R8631 86 31 0.5036202484966598
R8632 86 32 0.5374251451087476
R8633 86 33 0.7139173556049763
R8634 86 34 0.5077036811177104
R8635 86 35 0.8080511121308929
R8636 86 36 0.6859374707937742
R8637 86 37 1.0312736725508578
R8638 86 38 1.543141426970386
R8639 86 39 1.3907337719194488
R8640 86 40 0.80597833906495
R8641 86 41 1.7727472914250448
R8642 86 42 1.861617083310144
R8643 86 43 1.715515208017281
R8644 86 44 0.9560368320181002
R8645 86 45 1.2629052435283032
R8646 86 46 0.85866239404223
R8647 86 47 0.617376638976255
R8648 86 48 0.8299119441855519
R8649 86 49 1.0464165343704779
R8650 86 50 1.311846093268207
R8651 86 51 1.0313636164895368
R8652 86 52 1.8247643860419394
R8653 86 53 1.1629990989508063
R8654 86 54 1.4315440896864566
R8655 86 55 0.6593933651568339
R8656 86 56 0.7007155044596205
R8657 86 57 1.5306347237697442
R8658 86 58 0.6874282000881178
R8659 86 59 1.2048746405228896
R8660 86 60 1.6463964651527507
R8661 86 61 0.29256931540383435
R8662 86 62 0.30054295902679307
R8663 86 63 0.6806975383632162
R8664 86 64 1.4305142965974444
R8665 86 65 1.1184677084497738
R8666 86 66 0.5332569083627857
R8667 86 67 1.1756835771332037
R8668 86 68 0.26763891487602753
R8669 86 69 0.8276459794977759
R8670 86 70 0.7473672350332703
R8671 86 71 0.7874742545024416
R8672 86 72 1.5536227641571791
R8673 86 73 1.6566564654596423
R8674 86 74 0.3655219827915134
R8675 86 75 0.522431260004345
R8676 86 76 1.063805197869681
R8677 86 77 1.3722900445765716
R8678 86 78 1.17387405884071
R8679 86 79 1.478061015722377
R8680 86 80 0.7900930041161004
R8681 86 81 0.9368171819122539
R8682 86 82 1.0440547015436614
R8683 86 83 0.9038866885625277
R8684 86 84 0.9370821544533084
R8685 86 85 1.419473335396412
R8700 87 0 0.9924036333586147
R8701 87 1 1.0969147181754335
R8702 87 2 1.7934389640042177
R8703 87 3 0.8161534176918744
R8704 87 4 1.3022467623430762
R8705 87 5 0.76652663677505
R8706 87 6 0.6806555064940436
R8707 87 7 1.6029659364902449
R8708 87 8 0.739450131240847
R8709 87 9 0.6926865763637123
R8710 87 10 1.0438864269665389
R8711 87 11 1.0116596892163399
R8712 87 12 1.002046599139284
R8713 87 13 1.49874590350709
R8714 87 14 0.8072293348207231
R8715 87 15 1.2079701465060841
R8716 87 16 0.8324066554103869
R8717 87 17 1.09042378404231
R8718 87 18 1.8735392186728714
R8719 87 19 0.6467437395673398
R8720 87 20 0.19801456954994223
R8721 87 21 0.7374752502796619
R8722 87 22 0.5919437977097166
R8723 87 23 0.48500212079697924
R8724 87 24 0.8664400364872504
R8725 87 25 0.9235337330174029
R8726 87 26 0.9490722628946268
R8727 87 27 0.41820899349497664
R8728 87 28 0.7443129881575432
R8729 87 29 0.4453213607132376
R8730 87 30 1.5416958504889902
R8731 87 31 1.0110688649486193
R8732 87 32 1.0149298971227594
R8733 87 33 1.6114724393814406
R8734 87 34 0.18682613667670556
R8735 87 35 1.0188751558924476
R8736 87 36 1.0589367554794387
R8737 87 37 1.4877918987782957
R8738 87 38 0.2946911034965334
R8739 87 39 1.7467486813557107
R8740 87 40 1.8206777847507962
R8741 87 41 1.0352387588643714
R8742 87 42 1.1349359759723057
R8743 87 43 1.2110485969820677
R8744 87 44 0.8946658441064675
R8745 87 45 0.9171141328806542
R8746 87 46 0.9989971125729383
R8747 87 47 0.5354955883230414
R8748 87 48 1.5611768225894056
R8749 87 49 0.09883337277988258
R8750 87 50 1.822549511938468
R8751 87 51 1.253940509971312
R8752 87 52 0.7160233801950632
R8753 87 53 0.8618272646299955
R8754 87 54 0.1559696372917173
R8755 87 55 0.6875829951325267
R8756 87 56 1.221567026108651
R8757 87 57 0.6421278009400704
R8758 87 58 1.286608090261515
R8759 87 59 1.0258338959588096
R8760 87 60 0.8379900272929716
R8761 87 61 0.6394495232696618
R8762 87 62 1.4674817992295102
R8763 87 63 0.8285147962375355
R8764 87 64 0.6653658600336794
R8765 87 65 1.2086004640763306
R8766 87 66 1.7465110169429625
R8767 87 67 1.3411000793330745
R8768 87 68 1.0908938049764765
R8769 87 69 1.2730087421826812
R8770 87 70 0.8993045251756843
R8771 87 71 1.4277830009994548
R8772 87 72 0.6266059115127975
R8773 87 73 0.6843011937669339
R8774 87 74 0.4414207681217325
R8775 87 75 1.1925280296946317
R8776 87 76 1.5606335840020336
R8777 87 77 0.9724617154565139
R8778 87 78 1.5819272171042165
R8779 87 79 0.7026776067400172
R8780 87 80 1.0964192079919868
R8781 87 81 0.7445781043991684
R8782 87 82 0.618491952784087
R8783 87 83 0.35418707375854785
R8784 87 84 0.9923660293634841
R8785 87 85 1.1064849550217635
R8786 87 86 0.5403473004076318
R8800 88 0 0.1446825610575979
R8801 88 1 1.4108526083759787
R8802 88 2 0.8356250279657118
R8803 88 3 1.7014167277943089
R8804 88 4 1.0002194243153602
R8805 88 5 0.665893715536626
R8806 88 6 1.0074825866417565
R8807 88 7 1.4336198484974219
R8808 88 8 1.4206839095061112
R8809 88 9 0.6463901016239266
R8810 88 10 0.9973588580120706
R8811 88 11 0.4424607110586025
R8812 88 12 1.317034122821818
R8813 88 13 1.0099786785530946
R8814 88 14 0.658288616306297
R8815 88 15 0.9591747333646199
R8816 88 16 1.4259965671517505
R8817 88 17 0.7944863233925823
R8818 88 18 0.948539914448167
R8819 88 19 0.7512824892410455
R8820 88 20 1.103025479695238
R8821 88 21 0.5876585492401643
R8822 88 22 1.6347564719659307
R8823 88 23 0.5035341661344379
R8824 88 24 0.9716223979065393
R8825 88 25 0.5926279648062467
R8826 88 26 1.0353055948154566
R8827 88 27 0.9828233098583056
R8828 88 28 0.7772856245030928
R8829 88 29 0.7855966857735075
R8830 88 30 0.014806414887914565
R8831 88 31 0.8920622644926807
R8832 88 32 1.0829630331979319
R8833 88 33 1.5137208817639773
R8834 88 34 0.4380220932452711
R8835 88 35 1.4739505280681884
R8836 88 36 0.5697638199023675
R8837 88 37 1.14671692676798
R8838 88 38 1.4647400693339871
R8839 88 39 1.3009969154143142
R8840 88 40 1.128330137582195
R8841 88 41 0.731470267472813
R8842 88 42 0.5380695123104985
R8843 88 43 1.275420826572006
R8844 88 44 1.2935504028712748
R8845 88 45 1.3443970951623156
R8846 88 46 1.0312004557983738
R8847 88 47 1.1797192054026095
R8848 88 48 0.6522666876552566
R8849 88 49 0.48009285094111187
R8850 88 50 1.088750711493271
R8851 88 51 0.7163008405986462
R8852 88 52 0.8418627380699176
R8853 88 53 1.1017345094849702
R8854 88 54 0.7886309279155574
R8855 88 55 0.5480672790636049
R8856 88 56 0.6413687449031733
R8857 88 57 0.8548543069639236
R8858 88 58 1.2039514444294004
R8859 88 59 0.9067158651167405
R8860 88 60 1.1860644491424654
R8861 88 61 1.4879174928322505
R8862 88 62 1.9525764708258764
R8863 88 63 1.3978105548351902
R8864 88 64 0.9702483338200659
R8865 88 65 0.7956691047102484
R8866 88 66 1.1613654030465694
R8867 88 67 1.3431436203780152
R8868 88 68 0.41638990006036924
R8869 88 69 1.7746005255993271
R8870 88 70 0.98956766086239
R8871 88 71 1.0750101649121855
R8872 88 72 1.0922123598105626
R8873 88 73 0.9453800548768359
R8874 88 74 1.090251179056692
R8875 88 75 0.9131105064693589
R8876 88 76 0.2225254400356893
R8877 88 77 0.7042182991427018
R8878 88 78 0.46931632574642335
R8879 88 79 0.6665844775497018
R8880 88 80 0.728006737705951
R8881 88 81 1.0618332718903425
R8882 88 82 1.2869580645507694
R8883 88 83 1.1709892677875733
R8884 88 84 0.6700960316069854
R8885 88 85 0.545409828219853
R8886 88 86 1.8186497065222667
R8887 88 87 1.3129345651199933
R8900 89 0 1.069416859865784
R8901 89 1 0.8578345239912459
R8902 89 2 0.7945652770582685
R8903 89 3 0.5136195460220762
R8904 89 4 1.4425620777988248
R8905 89 5 0.7086658601284359
R8906 89 6 1.2301735209222866
R8907 89 7 1.0126104139632952
R8908 89 8 1.0035578799372296
R8909 89 9 0.6861939115478757
R8910 89 10 0.11615466254164142
R8911 89 11 1.0650700162880584
R8912 89 12 1.3981468614582502
R8913 89 13 1.372053366473681
R8914 89 14 0.4168857698859667
R8915 89 15 0.870283545755949
R8916 89 16 0.8202877292335575
R8917 89 17 1.6593151243634439
R8918 89 18 0.23588957343035732
R8919 89 19 0.8071268998133371
R8920 89 20 1.0575368642310445
R8921 89 21 1.2384241277013475
R8922 89 22 1.3021886211131743
R8923 89 23 0.4097071675078624
R8924 89 24 0.4574649227046773
R8925 89 25 0.5305067256493136
R8926 89 26 0.7748545646215523
R8927 89 27 0.2159967915356008
R8928 89 28 1.2370263820106193
R8929 89 29 0.9778794296511162
R8930 89 30 1.6684715223833155
R8931 89 31 0.6054798436526749
R8932 89 32 1.26958291810688
R8933 89 33 0.855809969398222
R8934 89 34 0.4117193815685779
R8935 89 35 0.9128856546029337
R8936 89 36 0.28808540933326243
R8937 89 37 1.2923571694438345
R8938 89 38 0.31846643471336356
R8939 89 39 1.040227605411721
R8940 89 40 0.9719066860692903
R8941 89 41 0.6385793410705334
R8942 89 42 1.3809096469832998
R8943 89 43 1.4344818315422032
R8944 89 44 1.4709277275300359
R8945 89 45 0.9907790787892388
R8946 89 46 0.938854920606816
R8947 89 47 0.9198067544386629
R8948 89 48 0.7151294715543113
R8949 89 49 0.30928422543178025
R8950 89 50 1.2786734268038287
R8951 89 51 1.1972961955554329
R8952 89 52 1.1558122562305246
R8953 89 53 0.3884601100132786
R8954 89 54 1.0630389806271714
R8955 89 55 0.8935737264557716
R8956 89 56 1.2170402947606171
R8957 89 57 1.0520615971066305
R8958 89 58 0.7674164891287805
R8959 89 59 0.5392259689384311
R8960 89 60 1.3643709803589785
R8961 89 61 0.7736593802092216
R8962 89 62 0.8548174463164967
R8963 89 63 1.0108143894839612
R8964 89 64 1.2403711162966327
R8965 89 65 0.8057953958348048
R8966 89 66 0.9261533310581329
R8967 89 67 0.8982988774267111
R8968 89 68 1.2743958078347513
R8969 89 69 1.2594112498682224
R8970 89 70 1.0618133751148258
R8971 89 71 0.2769014207554815
R8972 89 72 1.027567992553365
R8973 89 73 0.6048046380668917
R8974 89 74 0.6736181734440636
R8975 89 75 0.4099452211821545
R8976 89 76 0.25167405701000944
R8977 89 77 1.2550997426989436
R8978 89 78 1.6294984869132698
R8979 89 79 0.38452395651297433
R8980 89 80 0.8142674403928319
R8981 89 81 0.6283149261924195
R8982 89 82 0.7973758892078807
R8983 89 83 0.2675570719121738
R8984 89 84 0.7752076607050482
R8985 89 85 1.168582468367101
R8986 89 86 0.8430669814770713
R8987 89 87 1.359481607412321
R8988 89 88 1.3436192358488679
R9000 90 0 0.5997534722250502
R9001 90 1 0.44003476128717844
R9002 90 2 0.8189034057703943
R9003 90 3 0.7058247508905311
R9004 90 4 0.9743302600219503
R9005 90 5 1.7329679444361472
R9006 90 6 1.5650892770526088
R9007 90 7 1.0219516296829758
R9008 90 8 1.0116239604590942
R9009 90 9 1.538286651102847
R9010 90 10 0.9470887997356644
R9011 90 11 1.1090343239111478
R9012 90 12 0.8945975962633934
R9013 90 13 0.5400479770366412
R9014 90 14 0.3881230129046255
R9015 90 15 1.6704022109321475
R9016 90 16 1.3518855038056252
R9017 90 17 0.9512395620390613
R9018 90 18 0.26828274186456025
R9019 90 19 0.8507652579672751
R9020 90 20 1.2421393597455785
R9021 90 21 0.4952628320018547
R9022 90 22 1.3886398505335957
R9023 90 23 1.2101525000765352
R9024 90 24 1.3455031416419312
R9025 90 25 1.1902030334954183
R9026 90 26 0.7897770634727894
R9027 90 27 1.2962508261807764
R9028 90 28 1.0001837597901502
R9029 90 29 0.5233206323961521
R9030 90 30 0.9733772458679351
R9031 90 31 1.4284628667023984
R9032 90 32 0.9832850915052225
R9033 90 33 0.35020558299891347
R9034 90 34 1.1095213453587016
R9035 90 35 0.3999838884090563
R9036 90 36 1.1881912075347838
R9037 90 37 1.6510623988047648
R9038 90 38 0.7013458164419949
R9039 90 39 0.8252021896763481
R9040 90 40 1.1102756953057666
R9041 90 41 0.11196257450069758
R9042 90 42 0.8364527345100771
R9043 90 43 0.5416612867461683
R9044 90 44 0.49346110855816294
R9045 90 45 1.0801497872072563
R9046 90 46 1.1883641171058699
R9047 90 47 1.4243922272636544
R9048 90 48 0.21931955829562733
R9049 90 49 0.8636098521293567
R9050 90 50 1.0713367801065332
R9051 90 51 1.5371427827190352
R9052 90 52 1.1945582807290869
R9053 90 53 0.7568441826914799
R9054 90 54 1.042942163859649
R9055 90 55 1.1333982780927072
R9056 90 56 1.1991444395857283
R9057 90 57 0.5676336464393815
R9058 90 58 0.7840021970921206
R9059 90 59 1.3900849238962878
R9060 90 60 0.7486666040079206
R9061 90 61 1.6059855936062322
R9062 90 62 0.97967408164978
R9063 90 63 1.3726629874271437
R9064 90 64 0.8638553564355536
R9065 90 65 1.2245859574939595
R9066 90 66 1.3230275286031241
R9067 90 67 0.7447328295050859
R9068 90 68 1.0930330523036043
R9069 90 69 0.5081020591677032
R9070 90 70 1.2275552115131891
R9071 90 71 1.1420069385261549
R9072 90 72 1.2051256128967638
R9073 90 73 1.3820013160839983
R9074 90 74 0.6163294532350843
R9075 90 75 1.4022564217708062
R9076 90 76 0.8984766368462693
R9077 90 77 0.941931258421422
R9078 90 78 0.7937194293530941
R9079 90 79 1.3957355002547331
R9080 90 80 1.1069263264609537
R9081 90 81 1.3771470767763698
R9082 90 82 1.465587023285805
R9083 90 83 0.28281069985554796
R9084 90 84 0.8723790166682198
R9085 90 85 1.5117687872558343
R9086 90 86 0.6488193772227775
R9087 90 87 0.3043559100116484
R9088 90 88 1.039512735262481
R9089 90 89 0.3065785731821391
R9100 91 0 1.6111869371582488
R9101 91 1 0.3754038832395846
R9102 91 2 1.7300067802371673
R9103 91 3 0.3442353892324407
R9104 91 4 1.7689990134586615
R9105 91 5 1.723171982362442
R9106 91 6 1.217800728400916
R9107 91 7 0.9402262076553499
R9108 91 8 0.624827817108505
R9109 91 9 1.0762197930362603
R9110 91 10 1.2495298849646246
R9111 91 11 1.4857905187385256
R9112 91 12 0.7898678460997327
R9113 91 13 1.5566932888841956
R9114 91 14 1.5786750162762302
R9115 91 15 0.50736519749137
R9116 91 16 1.5045838374818292
R9117 91 17 1.1938771421135468
R9118 91 18 1.4814618001825721
R9119 91 19 1.7079209813927716
R9120 91 20 0.9747457344127045
R9121 91 21 0.9037197959522433
R9122 91 22 0.9082195372694247
R9123 91 23 0.24074227038349494
R9124 91 24 1.012912360252447
R9125 91 25 0.7801818974597049
R9126 91 26 0.7334575066009179
R9127 91 27 0.9039481000317514
R9128 91 28 0.24962318538708816
R9129 91 29 0.7166084965124678
R9130 91 30 0.559153851743607
R9131 91 31 0.7270545555914474
R9132 91 32 0.7536412128126643
R9133 91 33 0.7046375517686123
R9134 91 34 0.8455971418067556
R9135 91 35 1.3905573697763067
R9136 91 36 1.0414587137554263
R9137 91 37 0.31161980533424427
R9138 91 38 1.1512510975268648
R9139 91 39 0.4173397721168822
R9140 91 40 1.8653130150337949
R9141 91 41 0.9819773758987308
R9142 91 42 0.7978802758024206
R9143 91 43 0.9345740376137616
R9144 91 44 0.5298202658360122
R9145 91 45 1.4797293439766528
R9146 91 46 1.2564499221757433
R9147 91 47 0.9265111204506693
R9148 91 48 0.528611224485784
R9149 91 49 1.7507953325414845
R9150 91 50 0.29764372861422905
R9151 91 51 1.3254233300423883
R9152 91 52 1.4162914452140893
R9153 91 53 1.391354712986487
R9154 91 54 0.885269366163286
R9155 91 55 0.8987159143705455
R9156 91 56 1.2313206115260253
R9157 91 57 0.40025477025064793
R9158 91 58 0.5826355629153603
R9159 91 59 1.1506071721253115
R9160 91 60 0.8426670184388956
R9161 91 61 0.09225482727631962
R9162 91 62 1.2870908998587296
R9163 91 63 0.16432832072338166
R9164 91 64 1.106112479119873
R9165 91 65 1.0221041784366105
R9166 91 66 0.8397028628806454
R9167 91 67 1.1374962060811233
R9168 91 68 1.3583024888549056
R9169 91 69 0.2496345919190165
R9170 91 70 0.9511849208463838
R9171 91 71 0.47134543979273347
R9172 91 72 1.1404482043083932
R9173 91 73 1.2269049526970122
R9174 91 74 0.845740884180733
R9175 91 75 1.2393746075293723
R9176 91 76 0.8666103767779367
R9177 91 77 1.3719774312727886
R9178 91 78 1.5087556425580768
R9179 91 79 0.955480314804243
R9180 91 80 0.7713271082761735
R9181 91 81 1.2004553170499945
R9182 91 82 0.5916901166998583
R9183 91 83 0.3988389165833943
R9184 91 84 0.465414009050063
R9185 91 85 1.2131583734582572
R9186 91 86 0.9814673872330566
R9187 91 87 0.4358414216771118
R9188 91 88 0.7677708774078529
R9189 91 89 0.8913496081384552
R9190 91 90 0.2597186103106708
R9200 92 0 0.7459422540837854
R9201 92 1 0.8465049737143792
R9202 92 2 0.421807313509065
R9203 92 3 1.252915023935319
R9204 92 4 1.0791720986843094
R9205 92 5 1.2626805076832508
R9206 92 6 0.8180659051591523
R9207 92 7 0.9212202114863084
R9208 92 8 1.3496423683482748
R9209 92 9 1.7209715518233883
R9210 92 10 1.6478490147182652
R9211 92 11 0.9048411726616747
R9212 92 12 0.7188431989613404
R9213 92 13 0.9442679828651124
R9214 92 14 1.0366684314836254
R9215 92 15 0.8247827868468713
R9216 92 16 1.1491333238608554
R9217 92 17 1.0222992045344188
R9218 92 18 1.02310931073047
R9219 92 19 0.5756758511608814
R9220 92 20 0.996535958344742
R9221 92 21 1.3253677584536452
R9222 92 22 1.1399088781727607
R9223 92 23 1.1282815386453868
R9224 92 24 0.3910556550006853
R9225 92 25 1.0336780707034028
R9226 92 26 1.2303949583820426
R9227 92 27 1.4910265452113531
R9228 92 28 0.626482227766555
R9229 92 29 0.44185857599224476
R9230 92 30 0.3201737750139776
R9231 92 31 1.3898049805431658
R9232 92 32 0.37028369155988383
R9233 92 33 0.7405279128557185
R9234 92 34 1.134101317439871
R9235 92 35 0.6410559208357416
R9236 92 36 0.9403131318459372
R9237 92 37 0.9878903447487236
R9238 92 38 1.0895191364049164
R9239 92 39 1.3319724424031336
R9240 92 40 0.5525117800490901
R9241 92 41 0.9340753119548413
R9242 92 42 1.6181676130434133
R9243 92 43 1.066392414132596
R9244 92 44 1.7330158716761486
R9245 92 45 0.9318763240266863
R9246 92 46 1.1282391690431641
R9247 92 47 0.639520172491561
R9248 92 48 1.0460874886442375
R9249 92 49 0.6491336934201132
R9250 92 50 0.9416725645209846
R9251 92 51 1.32001889178628
R9252 92 52 1.3275352026805667
R9253 92 53 0.40665615232805796
R9254 92 54 1.1171649168480697
R9255 92 55 0.5482452252864133
R9256 92 56 0.8067836236959858
R9257 92 57 0.7570422891742125
R9258 92 58 0.5916422731165476
R9259 92 59 1.4640502833420226
R9260 92 60 0.5576729475847625
R9261 92 61 1.18112202589784
R9262 92 62 1.494937113303044
R9263 92 63 0.9508436573350487
R9264 92 64 0.9453318013969604
R9265 92 65 0.5670490469727449
R9266 92 66 1.004774561820159
R9267 92 67 0.4369363491597812
R9268 92 68 1.2725158215701766
R9269 92 69 1.215432065383099
R9270 92 70 1.1055197422812342
R9271 92 71 0.5213101738533904
R9272 92 72 0.8642050870902739
R9273 92 73 1.323520587251128
R9274 92 74 1.6390448885510214
R9275 92 75 0.593801417162485
R9276 92 76 0.5483376217299635
R9277 92 77 0.3779521234555945
R9278 92 78 1.5136236312919626
R9279 92 79 1.1545811280045573
R9280 92 80 1.1541025859654659
R9281 92 81 0.5585736497102433
R9282 92 82 1.5353299458245944
R9283 92 83 0.39850886204879576
R9284 92 84 1.3209051162889067
R9285 92 85 0.662623163334012
R9286 92 86 1.5144679934068925
R9287 92 87 0.912724739434807
R9288 92 88 1.279518607639387
R9289 92 89 0.8033888434351822
R9290 92 90 0.8634823656470756
R9291 92 91 1.0882970835703438
R9300 93 0 0.958218327936299
R9301 93 1 1.6346108806920339
R9302 93 2 0.9110422553568682
R9303 93 3 1.0261480122873592
R9304 93 4 1.5962324702526196
R9305 93 5 1.9040375948998243
R9306 93 6 1.2133921776592782
R9307 93 7 0.787737645824542
R9308 93 8 1.4142265739592812
R9309 93 9 0.3433133438531336
R9310 93 10 1.2375811718853682
R9311 93 11 0.9910842376770614
R9312 93 12 0.8763896223308755
R9313 93 13 1.525841196049249
R9314 93 14 1.35137826675615
R9315 93 15 1.106968634555741
R9316 93 16 1.2670412226893242
R9317 93 17 0.5374220641160008
R9318 93 18 1.1079582798829937
R9319 93 19 0.7492182725508808
R9320 93 20 0.7400642529307507
R9321 93 21 1.1277396208860544
R9322 93 22 1.638913956781908
R9323 93 23 1.0475715413861775
R9324 93 24 0.9785409510272124
R9325 93 25 1.0658702632682122
R9326 93 26 1.0208457188831417
R9327 93 27 0.8991136285935201
R9328 93 28 0.72854475105558
R9329 93 29 0.9497979341177736
R9330 93 30 1.1207307849638268
R9331 93 31 0.9568452341928356
R9332 93 32 0.5828041059865728
R9333 93 33 0.039382157989996336
R9334 93 34 0.788612776160014
R9335 93 35 0.7574253520555749
R9336 93 36 0.411587799127347
R9337 93 37 1.5041135319904753
R9338 93 38 1.0700402775796882
R9339 93 39 0.5460430253054205
R9340 93 40 0.8110863858093382
R9341 93 41 0.6634797271403869
R9342 93 42 1.2266006589205607
R9343 93 43 1.8053200707892678
R9344 93 44 0.7434819691595617
R9345 93 45 0.8857355014012818
R9346 93 46 0.38281434879996634
R9347 93 47 1.345561491758339
R9348 93 48 1.1173465368079847
R9349 93 49 1.1247119995098414
R9350 93 50 1.0295092765884926
R9351 93 51 0.7146672929899818
R9352 93 52 1.7007910313686014
R9353 93 53 1.2155907494158347
R9354 93 54 1.7523390494305797
R9355 93 55 0.376634177900078
R9356 93 56 0.45663876737342146
R9357 93 57 1.2320785800427543
R9358 93 58 0.8811731917922263
R9359 93 59 1.8707721437838025
R9360 93 60 1.0984989691734532
R9361 93 61 1.1050424091657167
R9362 93 62 0.844776545468859
R9363 93 63 0.6717987836293889
R9364 93 64 0.8039138063492425
R9365 93 65 0.847854627598927
R9366 93 66 0.4102426521978185
R9367 93 67 0.814142784152538
R9368 93 68 1.1212537698249783
R9369 93 69 0.34068509649178536
R9370 93 70 1.723153391413236
R9371 93 71 0.6678654105454915
R9372 93 72 0.6321475543079077
R9373 93 73 0.08263307193554104
R9374 93 74 0.29254713000911514
R9375 93 75 0.588695888524106
R9376 93 76 0.8656242086823894
R9377 93 77 0.7551081666854509
R9378 93 78 1.5389950086451503
R9379 93 79 1.7715657593029719
R9380 93 80 0.9243553123937855
R9381 93 81 0.6024210460978907
R9382 93 82 0.9163902600695679
R9383 93 83 0.12768285523775535
R9384 93 84 1.5676368833779262
R9385 93 85 0.8946436721598392
R9386 93 86 1.7593569497153951
R9387 93 87 0.8219986955944847
R9388 93 88 1.8859845072343606
R9389 93 89 0.9824969355648959
R9390 93 90 0.9032463288734133
R9391 93 91 1.3791189984524492
R9392 93 92 0.08125906233826163
R9400 94 0 1.1301176016929517
R9401 94 1 0.6432265471724414
R9402 94 2 1.124416946579633
R9403 94 3 0.616976395199179
R9404 94 4 0.583019290514718
R9405 94 5 1.3571728635159603
R9406 94 6 0.5757651894326276
R9407 94 7 0.9932320605485928
R9408 94 8 1.506708417999573
R9409 94 9 1.5244716026381535
R9410 94 10 0.44252780294678973
R9411 94 11 1.1570792128052776
R9412 94 12 1.0231755606832285
R9413 94 13 1.3589204626200133
R9414 94 14 0.9655978206161013
R9415 94 15 0.5946398642990728
R9416 94 16 1.1078432389205028
R9417 94 17 0.45068039754804545
R9418 94 18 1.3512592459064412
R9419 94 19 1.2922966447792197
R9420 94 20 0.7052978329258279
R9421 94 21 1.3015987893585406
R9422 94 22 1.8757039613754705
R9423 94 23 0.22835312295233712
R9424 94 24 1.1580380727694062
R9425 94 25 0.5910489345426465
R9426 94 26 1.1022602260443093
R9427 94 27 0.6689808554204218
R9428 94 28 0.9800135126212307
R9429 94 29 1.3818196206809237
R9430 94 30 0.6621188116750769
R9431 94 31 0.8736023890308239
R9432 94 32 1.0943957948471792
R9433 94 33 0.8250045366644909
R9434 94 34 1.577419469275232
R9435 94 35 1.3330266108412916
R9436 94 36 0.8810060644983653
R9437 94 37 0.6173289575339029
R9438 94 38 0.6830290923248665
R9439 94 39 1.443630057210465
R9440 94 40 0.718786116784132
R9441 94 41 1.3779799097043806
R9442 94 42 1.7232949069387393
R9443 94 43 1.4071191413221715
R9444 94 44 1.0972650786998315
R9445 94 45 0.7603762219517239
R9446 94 46 1.1057338217133044
R9447 94 47 0.6865635289091411
R9448 94 48 0.799707283866302
R9449 94 49 1.4418429030078261
R9450 94 50 0.9271611939755491
R9451 94 51 1.4532428048080788
R9452 94 52 1.4412759432109086
R9453 94 53 0.5287220400698278
R9454 94 54 0.7184931201177339
R9455 94 55 0.5480205190284015
R9456 94 56 1.211093006512332
R9457 94 57 1.3420320054346342
R9458 94 58 1.0828192326112265
R9459 94 59 1.5555739278447782
R9460 94 60 0.34094348616385484
R9461 94 61 1.2863881857955386
R9462 94 62 1.3009543941679804
R9463 94 63 1.9111967947012154
R9464 94 64 0.5028222388002594
R9465 94 65 1.6587187477725982
R9466 94 66 1.3189054780404836
R9467 94 67 1.0576560017194008
R9468 94 68 1.4670582857451333
R9469 94 69 0.49677569956290946
R9470 94 70 0.6707829451976435
R9471 94 71 0.782707309088893
R9472 94 72 0.7038581336909778
R9473 94 73 0.7393261067961509
R9474 94 74 0.5352619070757301
R9475 94 75 1.5109123873925916
R9476 94 76 0.15134628732279343
R9477 94 77 1.1877746168779875
R9478 94 78 0.1594139558826818
R9479 94 79 0.47190960835535334
R9480 94 80 0.5019116047351692
R9481 94 81 1.6768235262755709
R9482 94 82 1.07644732759537
R9483 94 83 1.8651912290867687
R9484 94 84 1.5175751837474833
R9485 94 85 1.6609882252279577
R9486 94 86 1.0980089811243026
R9487 94 87 1.053437013609372
R9488 94 88 0.39788395917201624
R9489 94 89 1.108333821527796
R9490 94 90 0.44591904532151627
R9491 94 91 0.9945087291754358
R9492 94 92 0.4177744672844953
R9493 94 93 0.8628523479946111
R9500 95 0 0.03344507696139365
R9501 95 1 0.9720988503181314
R9502 95 2 1.3574989984234103
R9503 95 3 0.6713366239733038
R9504 95 4 0.8018695774680668
R9505 95 5 0.6479364943459757
R9506 95 6 1.1713004455945648
R9507 95 7 1.467313217743808
R9508 95 8 1.4539225898905501
R9509 95 9 0.924916634370249
R9510 95 10 1.021934359131392
R9511 95 11 1.1428160768363864
R9512 95 12 1.179926145446025
R9513 95 13 0.4575613744869632
R9514 95 14 1.109652071168918
R9515 95 15 0.875045668653366
R9516 95 16 0.5981942334325732
R9517 95 17 1.6692196637820218
R9518 95 18 1.3216799758476088
R9519 95 19 0.9793406704082657
R9520 95 20 1.3380005138813456
R9521 95 21 1.4468318377121987
R9522 95 22 1.292165192256168
R9523 95 23 0.18437047415192964
R9524 95 24 1.2415747057723363
R9525 95 25 0.7763482016866206
R9526 95 26 0.7267423352433152
R9527 95 27 1.8478602721113018
R9528 95 28 0.9746235902980789
R9529 95 29 1.5712238887688268
R9530 95 30 1.7023682272252572
R9531 95 31 0.5218985169598208
R9532 95 32 1.0621135434444777
R9533 95 33 0.6630149769061223
R9534 95 34 0.5836963073866646
R9535 95 35 1.332824810116132
R9536 95 36 1.327522578642739
R9537 95 37 0.7041171328732982
R9538 95 38 0.5523600606495985
R9539 95 39 0.8213104982667704
R9540 95 40 1.2168819890843585
R9541 95 41 0.552731785695611
R9542 95 42 1.5667214541050893
R9543 95 43 0.9503321328950964
R9544 95 44 0.7235260979457653
R9545 95 45 1.1631220135996694
R9546 95 46 1.1393225405142133
R9547 95 47 0.9002993204039443
R9548 95 48 1.2350886365974612
R9549 95 49 0.23923225339318932
R9550 95 50 0.8249519998183948
R9551 95 51 1.771391668585426
R9552 95 52 0.7043637007137962
R9553 95 53 1.0085772409664089
R9554 95 54 1.4941233492694321
R9555 95 55 0.8021321441880279
R9556 95 56 0.1114707406585983
R9557 95 57 0.9154747392278816
R9558 95 58 0.9894177101074966
R9559 95 59 1.7735027563406003
R9560 95 60 0.9763022837448876
R9561 95 61 0.979071862484018
R9562 95 62 0.9544012085659664
R9563 95 63 0.9027865045135005
R9564 95 64 1.3884955214307046
R9565 95 65 1.6063853565868897
R9566 95 66 0.7267161440422532
R9567 95 67 0.734162512116517
R9568 95 68 1.057098999047008
R9569 95 69 1.557918726874713
R9570 95 70 1.225673720672015
R9571 95 71 0.8952566826987848
R9572 95 72 1.830663526037927
R9573 95 73 1.5645371424044088
R9574 95 74 1.034946730177871
R9575 95 75 1.31860411864076
R9576 95 76 0.6448489260442702
R9577 95 77 1.4836702839046096
R9578 95 78 1.4973406348187455
R9579 95 79 0.8593716410810258
R9580 95 80 0.22110866332957635
R9581 95 81 1.7265748292947465
R9582 95 82 1.2789899247517744
R9583 95 83 0.7416088697111608
R9584 95 84 0.49003884022854693
R9585 95 85 0.8641773829540047
R9586 95 86 0.8904958596520314
R9587 95 87 1.10295763270213
R9588 95 88 0.44212280757521727
R9589 95 89 1.4637139822883611
R9590 95 90 1.1962154722122178
R9591 95 91 1.6131466302624922
R9592 95 92 0.9593135718337213
R9593 95 93 0.4008757217960307
R9594 95 94 0.6684390297294728
R9600 96 0 0.9404096413133057
R9601 96 1 0.1971679030916622
R9602 96 2 0.8319671219522994
R9603 96 3 1.3786908710031458
R9604 96 4 1.2618510870885153
R9605 96 5 0.9433599854749029
R9606 96 6 1.2446404196969776
R9607 96 7 0.7804465210904844
R9608 96 8 0.7754902569105749
R9609 96 9 1.52793980784902
R9610 96 10 1.2171925027838615
R9611 96 11 1.338888512240374
R9612 96 12 1.9452987766098824
R9613 96 13 0.11268744088433924
R9614 96 14 1.698394418950024
R9615 96 15 0.8782708162773661
R9616 96 16 0.47786784380215064
R9617 96 17 0.8759769604191254
R9618 96 18 0.9002790445023178
R9619 96 19 1.3607558334086325
R9620 96 20 0.7017561963574296
R9621 96 21 1.4133505326005849
R9622 96 22 1.0256392156525218
R9623 96 23 0.3895844652187682
R9624 96 24 0.2482175851821503
R9625 96 25 0.743359684397627
R9626 96 26 1.7447772103308692
R9627 96 27 1.0009906035683267
R9628 96 28 1.6399801640273468
R9629 96 29 1.2167191141748717
R9630 96 30 1.2709916951900024
R9631 96 31 0.5388549587929623
R9632 96 32 0.7560335225089294
R9633 96 33 1.230006693907336
R9634 96 34 0.21838071530637748
R9635 96 35 0.33713720113883694
R9636 96 36 1.8792393527543259
R9637 96 37 1.1843045182994247
R9638 96 38 1.051887277255445
R9639 96 39 1.7365177795936209
R9640 96 40 0.4074201286301581
R9641 96 41 1.1200810635044163
R9642 96 42 0.8770852522651832
R9643 96 43 1.3743557549520586
R9644 96 44 0.9339098464629314
R9645 96 45 0.9575685344476315
R9646 96 46 0.5672723857933322
R9647 96 47 0.6222260003084163
R9648 96 48 0.8136492935701681
R9649 96 49 1.4015356362383828
R9650 96 50 1.8104752531081607
R9651 96 51 0.990225445410135
R9652 96 52 1.8297334147905269
R9653 96 53 0.29399144638575503
R9654 96 54 0.9571630579138208
R9655 96 55 0.5123836381437491
R9656 96 56 0.7629148239164733
R9657 96 57 1.208373991894411
R9658 96 58 1.774814137671474
R9659 96 59 0.15154670822419314
R9660 96 60 1.0778372906504265
R9661 96 61 1.5198059492165266
R9662 96 62 1.5864147891185545
R9663 96 63 0.6251338693560066
R9664 96 64 0.267948490984114
R9665 96 65 0.8587174880223702
R9666 96 66 0.9064676062437951
R9667 96 67 1.264646944655921
R9668 96 68 0.927785469829751
R9669 96 69 1.1504583143672251
R9670 96 70 0.494521865313611
R9671 96 71 1.1202333581322956
R9672 96 72 1.1800911871169735
R9673 96 73 0.9733057074418335
R9674 96 74 0.4809354065449388
R9675 96 75 1.6729902510241
R9676 96 76 0.7557411927027744
R9677 96 77 0.658138627961453
R9678 96 78 0.8041156454338892
R9679 96 79 0.5475359707368308
R9680 96 80 1.2975665693400191
R9681 96 81 1.0980216269902179
R9682 96 82 1.2313615283030779
R9683 96 83 0.49376817433477593
R9684 96 84 0.2895785702194452
R9685 96 85 1.0742613111542083
R9686 96 86 0.8992921211247662
R9687 96 87 0.7704486346150548
R9688 96 88 1.6286894591936758
R9689 96 89 0.7374546739268669
R9690 96 90 1.4862629657860746
R9691 96 91 1.0561231162610996
R9692 96 92 1.2594692879817897
R9693 96 93 0.6038489178799349
R9694 96 94 1.0246810961338684
R9695 96 95 0.830840974805006
R9700 97 0 1.7049215399918651
R9701 97 1 0.9415723603170535
R9702 97 2 1.11707887408667
R9703 97 3 1.2734855463593067
R9704 97 4 0.837085845854968
R9705 97 5 0.7420625239155396
R9706 97 6 0.5746378652326212
R9707 97 7 0.706538743123956
R9708 97 8 0.32056073840210486
R9709 97 9 0.8808502007619032
R9710 97 10 0.5839763281267585
R9711 97 11 0.6871692553972663
R9712 97 12 0.8674297294757645
R9713 97 13 0.4719448174527562
R9714 97 14 0.26281353251161255
R9715 97 15 0.9767721601018753
R9716 97 16 0.5333761121431688
R9717 97 17 0.14735016294672287
R9718 97 18 1.1939524957595768
R9719 97 19 0.21437290249081153
R9720 97 20 0.6439524471626112
R9721 97 21 0.9221902203154513
R9722 97 22 0.716857580998128
R9723 97 23 1.2465231250424837
R9724 97 24 0.8126082107437425
R9725 97 25 1.030492383322278
R9726 97 26 0.4841966555375494
R9727 97 27 0.7996496776402514
R9728 97 28 0.5069960501214015
R9729 97 29 0.9333545393899597
R9730 97 30 1.1148691633979197
R9731 97 31 1.1464750689089103
R9732 97 32 1.5130622694255051
R9733 97 33 1.5771170726290609
R9734 97 34 1.4091874627508836
R9735 97 35 0.5687481550381831
R9736 97 36 0.7312875439380511
R9737 97 37 0.9033481153590087
R9738 97 38 1.1197203236759161
R9739 97 39 1.7787469786765377
R9740 97 40 1.8334602279536805
R9741 97 41 0.19660883949241248
R9742 97 42 0.6846301244451973
R9743 97 43 1.3272527789873818
R9744 97 44 0.4906178213371636
R9745 97 45 0.8674935626306135
R9746 97 46 1.4468224912978194
R9747 97 47 0.9757704204990403
R9748 97 48 1.041528558437686
R9749 97 49 0.8414785478157002
R9750 97 50 0.9359003417583568
R9751 97 51 1.0089696953064502
R9752 97 52 0.8685861788368654
R9753 97 53 0.4256362391580978
R9754 97 54 0.9516976623733281
R9755 97 55 1.43924806383828
R9756 97 56 1.0422621752626486
R9757 97 57 0.1559173698018107
R9758 97 58 0.08384156525616682
R9759 97 59 0.4327549934088577
R9760 97 60 0.981855854793366
R9761 97 61 0.8374748201092806
R9762 97 62 0.6811061807698022
R9763 97 63 1.0368725279119406
R9764 97 64 1.1503865178979331
R9765 97 65 0.23125480793663955
R9766 97 66 0.9200814031769394
R9767 97 67 0.30391496226565584
R9768 97 68 1.0300375002188975
R9769 97 69 1.6728372161153997
R9770 97 70 1.8639010059810468
R9771 97 71 1.1937370083866785
R9772 97 72 1.370844317518934
R9773 97 73 1.5379318367234283
R9774 97 74 0.7052623328317932
R9775 97 75 0.5716039114512868
R9776 97 76 1.3577730005366697
R9777 97 77 0.4934462434314657
R9778 97 78 0.47624599928657263
R9779 97 79 0.8462059808491932
R9780 97 80 1.3171542826091476
R9781 97 81 0.9501176648609666
R9782 97 82 1.5650098272330735
R9783 97 83 1.2739091253306754
R9784 97 84 1.5637981834402268
R9785 97 85 1.1298882775141257
R9786 97 86 0.7638465445596121
R9787 97 87 0.7903861447828295
R9788 97 88 1.300292387979651
R9789 97 89 1.6007651829592235
R9790 97 90 0.39437419547730446
R9791 97 91 0.7777491659160652
R9792 97 92 0.8976797176426224
R9793 97 93 0.7928712352487556
R9794 97 94 1.1536261465537807
R9795 97 95 1.1131214979730482
R9796 97 96 0.9028376221369723
R9800 98 0 1.1262323232697873
R9801 98 1 0.5475175258444832
R9802 98 2 0.13057902166017055
R9803 98 3 0.9898982728561482
R9804 98 4 1.0421463833547824
R9805 98 5 0.38782074768337615
R9806 98 6 0.9979666238353359
R9807 98 7 1.7046730382658248
R9808 98 8 0.6710051930031851
R9809 98 9 0.6293269672662942
R9810 98 10 1.1766282311225609
R9811 98 11 1.2156183969103813
R9812 98 12 1.3473785094169344
R9813 98 13 0.6355575511176427
R9814 98 14 0.5283349040926963
R9815 98 15 1.5191249059523
R9816 98 16 0.860285341702866
R9817 98 17 0.5267572264582912
R9818 98 18 0.3884076844483324
R9819 98 19 0.9003134486650367
R9820 98 20 0.8923884927237511
R9821 98 21 0.5156376123804682
R9822 98 22 1.3557722109824721
R9823 98 23 1.3973726879627453
R9824 98 24 1.0064604771253824
R9825 98 25 1.1876430322564153
R9826 98 26 0.8462793217878349
R9827 98 27 1.6853453220667935
R9828 98 28 0.8225739103749989
R9829 98 29 1.2138363309903768
R9830 98 30 1.0321900285829473
R9831 98 31 0.3145391620008884
R9832 98 32 0.3537616810659301
R9833 98 33 0.8273680282442072
R9834 98 34 1.1239294602431515
R9835 98 35 0.7235323801223638
R9836 98 36 0.804777587803942
R9837 98 37 1.0088008831320496
R9838 98 38 0.7892056158200942
R9839 98 39 1.0680417229049426
R9840 98 40 1.2390220142443873
R9841 98 41 1.2818555964373903
R9842 98 42 1.1637020540549439
R9843 98 43 1.6626009195919247
R9844 98 44 1.0949763907129295
R9845 98 45 1.3276854211997091
R9846 98 46 0.6299870368986034
R9847 98 47 0.534565181857467
R9848 98 48 0.519263679415461
R9849 98 49 0.6452311239776364
R9850 98 50 0.19244250658680884
R9851 98 51 0.44496350471430324
R9852 98 52 1.3052342309488676
R9853 98 53 1.1752872969698673
R9854 98 54 0.9281794683174995
R9855 98 55 0.4158836966992109
R9856 98 56 1.1225140439719783
R9857 98 57 0.9926919769602734
R9858 98 58 1.3744484779678756
R9859 98 59 1.3198464329462967
R9860 98 60 0.7599950316493767
R9861 98 61 0.994107950997715
R9862 98 62 1.061282020893075
R9863 98 63 1.6698284479609802
R9864 98 64 1.025699291374719
R9865 98 65 0.7430529120328587
R9866 98 66 1.8247177607487948
R9867 98 67 1.008024597625643
R9868 98 68 1.232542158167972
R9869 98 69 1.05334086647526
R9870 98 70 0.5628876865169209
R9871 98 71 0.7581808747564245
R9872 98 72 0.8864899291735221
R9873 98 73 0.409748628963462
R9874 98 74 1.118186185101112
R9875 98 75 1.1798786395253806
R9876 98 76 1.0648907970201846
R9877 98 77 1.2217751240215744
R9878 98 78 1.6724116885272826
R9879 98 79 0.6412047480080201
R9880 98 80 1.2924151050929837
R9881 98 81 0.6110229791946266
R9882 98 82 1.1033670917962657
R9883 98 83 0.1087948968775152
R9884 98 84 0.8909529249211545
R9885 98 85 0.7208335949359916
R9886 98 86 1.2115060437564482
R9887 98 87 0.6926000910756746
R9888 98 88 0.8530152928323705
R9889 98 89 1.4456890989415638
R9890 98 90 0.7353256564806165
R9891 98 91 0.3505472288585969
R9892 98 92 0.5184888732257934
R9893 98 93 0.6411590118885536
R9894 98 94 1.29392123169617
R9895 98 95 0.6248736330895909
R9896 98 96 0.7074051705195455
R9897 98 97 0.7572074271939362
R9900 99 0 0.47134123658540406
R9901 99 1 1.0196872139175017
R9902 99 2 1.4939836374921336
R9903 99 3 0.03954140356675162
R9904 99 4 0.8400671056042621
R9905 99 5 1.1157177085234422
R9906 99 6 1.7801463740039956
R9907 99 7 1.5193353102760412
R9908 99 8 1.4813369684130613
R9909 99 9 1.1866457580231256
R9910 99 10 0.6970172115221454
R9911 99 11 1.1519688501318162
R9912 99 12 1.0635881428569347
R9913 99 13 0.8741360287144428
R9914 99 14 0.8631127341581971
R9915 99 15 1.337054720211458
R9916 99 16 1.7260195262390023
R9917 99 17 1.1252786870401543
R9918 99 18 1.1487261523387238
R9919 99 19 1.192587354017752
R9920 99 20 0.9995360289126962
R9921 99 21 0.5573712342208997
R9922 99 22 1.0413143184263278
R9923 99 23 0.9094022205732275
R9924 99 24 1.3851086155469026
R9925 99 25 1.4714909310695876
R9926 99 26 1.1760485117824624
R9927 99 27 0.3781916517880016
R9928 99 28 1.2767595643834428
R9929 99 29 1.4844001431312246
R9930 99 30 0.8428713123952019
R9931 99 31 0.2929212303221922
R9932 99 32 0.7485382067810574
R9933 99 33 0.4364506178975892
R9934 99 34 1.481444775727382
R9935 99 35 0.6541345468574418
R9936 99 36 1.7813651549412821
R9937 99 37 1.7362507504262978
R9938 99 38 1.0003147777151558
R9939 99 39 0.9588335511938262
R9940 99 40 1.0470956667583808
R9941 99 41 0.12157916191006723
R9942 99 42 0.3951272147513124
R9943 99 43 1.4038615381703035
R9944 99 44 1.0851368204203422
R9945 99 45 1.2157546802888792
R9946 99 46 0.48984980520916543
R9947 99 47 0.7227258610619911
R9948 99 48 0.4087368254145155
R9949 99 49 1.30049233670581
R9950 99 50 0.5874960617473793
R9951 99 51 0.8031132366973689
R9952 99 52 1.7920056213863877
R9953 99 53 1.0870403973167742
R9954 99 54 0.33390768152022965
R9955 99 55 0.9501377124500129
R9956 99 56 0.8899501026350172
R9957 99 57 0.6796375645974295
R9958 99 58 1.4476099266842488
R9959 99 59 0.6146331287779947
R9960 99 60 0.6177337779180424
R9961 99 61 0.37504327838876117
R9962 99 62 0.7411988484624854
R9963 99 63 1.1633462258687017
R9964 99 64 0.7056967348345352
R9965 99 65 1.0274353814092718
R9966 99 66 0.8922255539989838
R9967 99 67 0.7278833461474368
R9968 99 68 0.3647351481316162
R9969 99 69 0.9690440139131852
R9970 99 70 1.0782923473404902
R9971 99 71 0.5935534467394415
R9972 99 72 0.633619168524866
R9973 99 73 1.2310066868079452
R9974 99 74 1.038052607204029
R9975 99 75 1.0458149995052448
R9976 99 76 0.6001015274430153
R9977 99 77 1.5258105427420876
R9978 99 78 0.9227125892241257
R9979 99 79 0.5183766899741865
R9980 99 80 1.5914256507140352
R9981 99 81 0.7456626137891136
R9982 99 82 1.34650099355843
R9983 99 83 0.4337622467985671
R9984 99 84 1.0655935463851254
R9985 99 85 0.8724953871223213
R9986 99 86 1.114261318507701
R9987 99 87 0.6882968385310587
R9988 99 88 0.8739432750473797
R9989 99 89 0.775170551939022
R9990 99 90 0.5547722447100388
R9991 99 91 1.0645969779150266
R9992 99 92 1.3114528157117766
R9993 99 93 0.6185520432498933
R9994 99 94 0.5789518638325616
R9995 99 95 1.5671909035583687
R9996 99 96 1.3037723644179842
R9997 99 97 0.8158434882272794
R9998 99 98 1.4482470426155816
V1 99 0 5
.model D D
.lib /Users/lancemathias/Library/Application Support/LTspice/lib/cmp/standard.dio
.op
.backanno
.end
