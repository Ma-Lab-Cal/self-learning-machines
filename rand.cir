.title rand
R0 23 34 0.6997803985725287
R1 32 58 1.2479423575745532
R2 63 73 0.5894818103274538
V17 17 0 1.0
V45 45 0 1.0
V51 51 0 1.0
.op
