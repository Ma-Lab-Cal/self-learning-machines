.title clamped
R0 0 1 1.4040611326319912
R1 0 2 2.838089829225798
R2 0 3 1.0951197341189212
R3 0 5 0.8160783417369114
R4 0 6 0.47165006180008573
R5 0 7 1.2857199122785206
R6 0 8 0.9588652368339798
R7 0 9 0.6550773158630436
R8 1 2 2.800033476557004
R9 1 3 0.758443839243806
R10 1 4 1.5581456904353304
R11 1 7 0.9991497497090381
R12 1 9 0.4933550737657658
R13 2 3 2.034484700087834
R14 2 4 1.818249504220441
R15 2 5 1.9756789548154523
R16 2 6 1.6190269553713923
R17 2 7 2.007763557128341
R18 2 9 2.2685969727814976
R19 3 4 1.0876259257514496
R20 3 6 1.1243058546817726
R21 3 7 1.2419157422515046
R22 3 8 0.6551258716824598
R23 3 9 1.0088480695350937
R24 4 5 0.8477610104709036
R25 4 6 0.9995393570203136
R26 4 7 1.0937608509141288
R27 4 8 1.1744025243594018
R28 4 9 0.8731229774036524
R29 5 6 0.8726450372450762
R30 5 7 1.5920581468319768
R31 5 8 1.0470195390053594
R32 5 9 1.238822053545255
R33 6 7 1.0576224026931813
R34 6 9 0.8918419365142544
R35 7 8 0.777585253717575
R36 7 9 0.5969631374910294
R37 8 9 0.8432727131925057
V1 1 0 0.9559031559566273
V6 6 0 0.23042565400950255
V2 2 0 0.0
.op
