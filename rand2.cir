.title rand2
R0 0 1 0.6611177209359382
R1 0 2 0.6639221374204938
R2 0 3 0.40984361463802943
R3 0 4 0.6218795803887485
R4 0 5 0.7209273276465569
R5 0 6 0.44403487047121215
R6 0 7 0.9459569965108552
R7 0 8 0.19955611640168613
R8 0 9 0.3434821510487609
R9 0 10 0.411894746210381
R10 0 11 0.2786379553195757
R11 0 12 0.26959909577232805
R12 0 13 0.33924879893698817
R13 0 14 0.34163974858931256
R14 0 15 0.26663693573556985
R15 0 16 0.5789394254656688
R16 0 17 0.5125823003597494
R17 0 18 0.3696035435022338
R18 0 19 0.39078119643069126
R19 1 2 0.5421360230205108
R20 1 3 0.7306429831927301
R21 1 4 0.6045723865932702
R22 1 5 0.24800852388171457
R23 1 6 0.20437783758556016
R24 1 7 0.43129728003518336
R25 1 8 0.7304873255559394
R26 1 9 0.5523850274600943
R27 1 10 0.5093564738979239
R28 1 11 0.9251555743998006
R29 1 12 0.5696848580564529
R30 1 13 0.38127545662801127
R31 1 14 0.4364157405088918
R32 1 15 0.4363947060913663
R33 1 16 0.6139060471362592
R34 1 17 0.4085910903483212
R35 1 18 0.7030082971231253
R36 1 19 0.7452369331573812
R37 2 3 0.08236186812103324
R38 2 4 0.5043244133711795
R39 2 5 0.17826061199047222
R40 2 6 0.469128437130273
R41 2 7 0.12675202841402955
R42 2 8 0.30203727461396884
R43 2 9 0.12750789215657293
R44 2 10 0.5022269458465722
R45 2 11 0.6762003947506214
R46 2 12 0.3654870587366953
R47 2 13 0.48932639685977364
R48 2 14 0.8240234127076351
R49 2 15 0.8485729614999677
R50 2 16 0.6186679243176672
R51 2 17 0.5443590335925999
R52 2 18 0.6677916648788221
R53 2 19 0.7992773979398473
R54 3 4 0.22289904128494165
R55 3 5 0.5495592335109903
R56 3 6 0.390282302377732
R57 3 7 0.7894823663096235
R58 3 8 0.3991409902772179
R59 3 9 0.567637434303867
R60 3 10 0.36490095358283514
R61 3 11 0.38993125861722977
R62 3 12 0.8646983145532185
R63 3 13 0.43148408103364466
R64 3 14 0.39383784082256534
R65 3 15 0.5923203126767718
R66 3 16 0.3778201937508534
R67 3 17 0.3706828096372355
R68 3 18 0.5401367086085471
R69 3 19 0.919152577984694
R70 4 5 0.3852612676341385
R71 4 6 0.5791769097393
R72 4 7 0.4715750188668025
R73 4 8 0.42467348849548237
R74 4 9 0.21696001861853725
R75 4 10 0.6285125034561836
R76 4 11 0.6052395186980992
R77 4 12 0.6736889330499822
R78 4 13 0.8944748764745553
R79 4 14 0.7886107421348733
R80 4 15 0.7585704293954209
R81 4 16 0.9347864164424389
R82 4 17 0.8009433832188315
R83 4 18 0.4383507107501895
R84 4 19 0.3361709223236448
R85 5 6 0.251158903071692
R86 5 7 0.7205212810764152
R87 5 8 0.7920680408705365
R88 5 9 0.2788458556294915
R89 5 10 0.5004166245326718
R90 5 11 0.7311961505282745
R91 5 12 0.15959246962947804
R92 5 13 0.584992598388203
R93 5 14 0.4437100180137027
R94 5 15 0.2545080092814824
R95 5 16 0.6672007493952318
R96 5 17 0.5397092830620842
R97 5 18 0.7043473668596327
R98 5 19 0.5546404628101635
R99 6 7 0.7020632249889649
R100 6 8 0.6665615030319905
R101 6 9 0.24960083526105276
R102 6 10 0.7909345259201174
R103 6 11 0.45732577723096784
R104 6 12 0.8345294335229277
R105 6 13 0.6159083110991813
R106 6 14 0.8576062278184553
R107 6 15 0.6279168345021946
R108 6 16 0.7089077603140501
R109 6 17 0.4815479162450796
R110 6 18 0.5778816678679817
R111 6 19 0.5902655058425601
R112 7 8 0.9797868464264201
R113 7 9 0.7421830222239649
R114 7 10 0.07250253907661691
R115 7 11 0.47683781063590863
R116 7 12 0.4796136104181195
R117 7 13 0.558461741345649
R118 7 14 0.5061043865676365
R119 7 15 0.5561974691407867
R120 7 16 0.45519943591357576
R121 7 17 0.4953246688545069
R122 7 18 0.540508724924609
R123 7 19 0.5286284457340522
R124 8 9 0.6087771761164528
R125 8 10 0.49949450825716724
R126 8 11 0.38612343679642874
R127 8 12 0.5681634493733048
R128 8 13 0.3900717855739715
R129 8 14 0.4241914155209559
R130 8 15 0.043009132782527604
R131 8 16 0.39535193841021266
R132 8 17 0.6858551305225224
R133 8 18 0.4096589325945572
R134 8 19 0.2679733815865515
R135 9 10 0.3771329535229781
R136 9 11 0.32448856180812724
R137 9 12 0.43881004684590824
R138 9 13 0.5997966084727246
R139 9 14 0.29152731685676136
R140 9 15 0.3425157536665633
R141 9 16 0.7146462132429574
R142 9 17 0.5085842308830244
R143 9 18 0.6755768522738604
R144 9 19 0.8871447313713254
R145 10 11 0.4505862683699966
R146 10 12 0.8414873566259068
R147 10 13 0.42788795874025043
R148 10 14 0.6197472339122795
R149 10 15 0.9739353931839063
R150 10 16 0.8010027744438819
R151 10 17 0.24919842636940404
R152 10 18 0.6707623432469549
R153 10 19 0.8693324971193324
R154 11 12 0.4725840043881791
R155 11 13 0.5669603051086897
R156 11 14 0.4441389007783836
R157 11 15 0.6478588799181418
R158 11 16 0.4640699946348538
R159 11 17 0.7064925467892749
R160 11 18 0.28980733008451726
R161 11 19 0.4519387061926658
R162 12 13 0.6259637899002581
R163 12 14 0.4265985560275106
R164 12 15 0.5432502756919639
R165 12 16 0.24259099796203387
R166 12 17 0.2578871774548542
R167 12 18 0.42655757975016595
R168 12 19 0.6884926188159739
R169 13 14 0.7691096698752029
R170 13 15 0.6996941465801745
R171 13 16 0.43460593697233807
R172 13 17 0.5918465042547519
R173 13 18 0.47828988549031026
R174 13 19 0.4437503270897068
R175 14 15 0.8460873642852372
R176 14 16 0.7208756632508904
R177 14 17 0.16927630767403196
R178 14 18 0.6655701149199766
R179 14 19 0.9257451520090226
R180 15 16 0.4162741265225666
R181 15 17 0.5357976621939934
R182 15 18 0.6253936330237126
R183 15 19 0.47326869982146635
R184 16 17 0.37723192734792316
R185 16 18 0.6575687532727184
R186 16 19 0.274583626625952
R187 17 18 0.5127207908109128
R188 17 19 0.270813964941713
R189 18 19 0.6303448801772873
V6 6 0 1.0
V8 8 0 1.0
V16 16 0 1.0
.op
