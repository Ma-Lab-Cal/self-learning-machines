.title sus
R0 0 2 0.349827898233006
R1 0 4 1.196368438170716
R2 0 5 0.9407957133122234
R3 0 7 0.8287327797193977
R4 0 9 1.2840057679997932
R5 1 2 1.544486651892592
R6 1 4 0.8877696926219039
R7 1 6 1.143300444686718
R8 1 7 1.2307530363836312
R9 1 8 0.7437506700329561
R10 1 9 1.1889640242577637
R11 2 5 1.3453639266543722
R12 2 6 1.0404516462294726
R13 2 8 0.8836290508469532
R14 2 9 1.701767684004634
R15 3 4 1.1097584846355968
R16 3 5 1.0304838237165077
R17 3 7 1.314204572114678
R18 4 9 1.1315105020541751
R19 5 6 1.5672275910398454
R20 5 9 0.18634147290673608
R21 6 7 1.7096438793487954
R22 6 8 0.6081549069136544
R23 6 9 0.9900999658917478
R24 7 8 0.7871534322277741
R25 7 9 1.884077569613963
V4 4 0 1.0
V7 7 0 1.0
V9 9 0 1.0
.op
