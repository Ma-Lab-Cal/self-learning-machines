.title min
R0 0 4 1.1525452209807203
R1 0 5 1.133746748189952
R2 1 4 1.231106209414787
R3 1 5 0.15927560914338731
R4 2 4 1.000226576752371e-06
R5 2 5 1.2593273669068368
V1 1 0 0.7999999999999996
V2 2 0 0.7999999999999996
.op
